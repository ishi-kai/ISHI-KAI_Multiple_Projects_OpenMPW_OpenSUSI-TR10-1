v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 740 -320 760 -320 {lab=#net1}
N 760 -390 780 -390 {lab=VDD}
N 760 -270 780 -270 {lab=VSS}
N 740 -360 760 -360 {lab=ffout1}
N 740 -420 740 -360 {lab=ffout1}
N 740 -420 840 -420 {lab=ffout1}
N 840 -420 840 -320 {lab=ffout1}
N 820 -320 840 -320 {lab=ffout1}
N 820 -360 860 -360 {lab=#net2}
N 860 -320 900 -320 {lab=#net2}
N 900 -390 920 -390 {lab=VDD}
N 900 -270 920 -270 {lab=VSS}
N 880 -360 900 -360 {lab=ffout2}
N 880 -420 880 -360 {lab=ffout2}
N 880 -420 980 -420 {lab=ffout2}
N 980 -420 980 -320 {lab=ffout2}
N 960 -320 980 -320 {lab=ffout2}
N 960 -360 1000 -360 {lab=#net3}
N 860 -360 860 -320 {lab=#net2}
N 1000 -320 1040 -320 {lab=#net3}
N 1040 -390 1060 -390 {lab=VDD}
N 1040 -270 1060 -270 {lab=VSS}
N 1020 -360 1040 -360 {lab=ffout4}
N 1020 -420 1020 -360 {lab=ffout4}
N 1020 -420 1120 -420 {lab=ffout4}
N 1120 -420 1120 -320 {lab=ffout4}
N 1100 -320 1120 -320 {lab=ffout4}
N 1100 -360 1140 -360 {lab=#net4}
N 1000 -360 1000 -320 {lab=#net3}
N 1140 -320 1180 -320 {lab=#net4}
N 1180 -390 1200 -390 {lab=VDD}
N 1180 -270 1200 -270 {lab=VSS}
N 1160 -360 1180 -360 {lab=ffout8}
N 1160 -420 1160 -360 {lab=ffout8}
N 1160 -420 1260 -420 {lab=ffout8}
N 1260 -420 1260 -320 {lab=ffout8}
N 1240 -320 1260 -320 {lab=ffout8}
N 1240 -360 1280 -360 {lab=#net5}
N 1140 -360 1140 -320 {lab=#net4}
N 1280 -320 1320 -320 {lab=#net5}
N 1320 -390 1340 -390 {lab=VDD}
N 1320 -270 1340 -270 {lab=VSS}
N 1300 -360 1320 -360 {lab=ffout16}
N 1300 -420 1300 -360 {lab=ffout16}
N 1300 -420 1400 -420 {lab=ffout16}
N 1400 -420 1400 -320 {lab=ffout16}
N 1380 -320 1400 -320 {lab=ffout16}
N 1380 -360 1420 -360 {lab=#net6}
N 1280 -360 1280 -320 {lab=#net5}
N 1420 -320 1460 -320 {lab=#net6}
N 1460 -390 1480 -390 {lab=VDD}
N 1460 -270 1480 -270 {lab=VSS}
N 1440 -360 1460 -360 {lab=ffout32}
N 1440 -420 1440 -360 {lab=ffout32}
N 1440 -420 1540 -420 {lab=ffout32}
N 1540 -420 1540 -320 {lab=ffout32}
N 1520 -320 1540 -320 {lab=ffout32}
N 1520 -360 1560 -360 {lab=#net7}
N 1420 -360 1420 -320 {lab=#net6}
N 1560 -320 1600 -320 {lab=#net7}
N 1600 -390 1620 -390 {lab=VDD}
N 1600 -270 1620 -270 {lab=VSS}
N 1580 -360 1600 -360 {lab=ffout64}
N 1580 -420 1580 -360 {lab=ffout64}
N 1580 -420 1680 -420 {lab=ffout64}
N 1680 -420 1680 -320 {lab=ffout64}
N 1660 -320 1680 -320 {lab=ffout64}
N 1560 -360 1560 -320 {lab=#net7}
N 840 -480 840 -420 {lab=ffout1}
N 800 -550 800 -530 {lab=VDD}
N 880 -550 880 -530 {lab=VSS}
N 840 -640 840 -600 {lab=d1_b}
N 800 -710 800 -690 {lab=VDD}
N 880 -710 880 -690 {lab=VSS}
N 840 -1020 840 -760 {lab=d1}
N 980 -480 980 -420 {lab=ffout2}
N 940 -550 940 -530 {lab=VDD}
N 1020 -550 1020 -530 {lab=VSS}
N 980 -640 980 -600 {lab=d2_b}
N 940 -710 940 -690 {lab=VDD}
N 1020 -710 1020 -690 {lab=VSS}
N 980 -980 980 -760 {lab=d2}
N 1120 -480 1120 -420 {lab=ffout4}
N 1080 -550 1080 -530 {lab=VDD}
N 1160 -550 1160 -530 {lab=VSS}
N 1120 -640 1120 -600 {lab=d4_b}
N 1080 -710 1080 -690 {lab=VDD}
N 1160 -710 1160 -690 {lab=VSS}
N 1120 -940 1120 -760 {lab=d4}
N 1260 -480 1260 -420 {lab=ffout8}
N 1220 -550 1220 -530 {lab=VDD}
N 1300 -550 1300 -530 {lab=VSS}
N 1260 -640 1260 -600 {lab=d8_b}
N 1220 -710 1220 -690 {lab=VDD}
N 1300 -710 1300 -690 {lab=VSS}
N 1260 -900 1260 -760 {lab=d8}
N 1400 -480 1400 -420 {lab=ffout16}
N 1360 -550 1360 -530 {lab=VDD}
N 1440 -550 1440 -530 {lab=VSS}
N 1400 -640 1400 -600 {lab=d16_b}
N 1360 -710 1360 -690 {lab=VDD}
N 1440 -710 1440 -690 {lab=VSS}
N 1400 -860 1400 -760 {lab=d16}
N 1540 -480 1540 -420 {lab=ffout32}
N 1500 -550 1500 -530 {lab=VDD}
N 1580 -550 1580 -530 {lab=VSS}
N 1540 -640 1540 -600 {lab=d32_b}
N 1500 -710 1500 -690 {lab=VDD}
N 1580 -710 1580 -690 {lab=VSS}
N 1540 -820 1540 -760 {lab=d32}
N 1680 -480 1680 -420 {lab=ffout64}
N 1640 -550 1640 -530 {lab=VDD}
N 1720 -550 1720 -530 {lab=VSS}
N 1680 -640 1680 -600 {lab=d64_b}
N 1640 -710 1640 -690 {lab=VDD}
N 1720 -710 1720 -690 {lab=VSS}
N 1680 -780 1680 -760 {lab=d64}
N 1740 -7080 1740 -620 {lab=d64_b}
N 1720 -7080 1720 -780 {lab=d64}
N 1700 -7080 1700 -800 {lab=d32_b}
N 1680 -7080 1680 -820 {lab=d32}
N 1660 -7080 1660 -840 {lab=d16_b}
N 1640 -7080 1640 -860 {lab=d16}
N 1620 -7080 1620 -880 {lab=d8_b}
N 1600 -7080 1600 -900 {lab=d8}
N 1580 -7080 1580 -920 {lab=d4_b}
N 1560 -7080 1560 -940 {lab=d4}
N 1540 -7080 1540 -960 {lab=d2_b}
N 1520 -7080 1520 -980 {lab=d2}
N 1500 -7080 1500 -1000 {lab=d1_b}
N 1480 -7080 1480 -1020 {lab=d1}
N 1740 -1320 2060 -1320 {lab=d64_b}
N 1700 -1340 2060 -1340 {lab=d32_b}
N 1660 -1360 2060 -1360 {lab=d16_b}
N 1600 -1380 2060 -1380 {lab=d8}
N 1580 -1400 2060 -1400 {lab=d4_b}
N 1540 -1420 2060 -1420 {lab=d2_b}
N 1480 -1440 2060 -1440 {lab=d1}
N 1720 -1160 2060 -1160 {lab=d64}
N 1680 -1180 2060 -1180 {lab=d32}
N 1640 -1200 2060 -1200 {lab=d16}
N 1600 -1220 2060 -1220 {lab=d8}
N 1560 -1240 2060 -1240 {lab=d4}
N 1520 -1260 2060 -1260 {lab=d2}
N 1500 -1280 2060 -1280 {lab=d1_b}
N 680 -80 2140 -80 {lab=#net1}
N 740 -320 740 -80 {lab=#net1}
N 2140 -7340 2140 -80 {lab=#net1}
N 3240 -1300 3280 -1300 {lab=P_SEL}
N 2080 -1480 2100 -1480 {lab=VDD}
N 2080 -1120 2100 -1120 {lab=VSS}
N 3170 -1340 3190 -1340 {lab=VDD}
N 3170 -1260 3190 -1260 {lab=VSS}
N 470 -120 490 -120 {lab=VDD}
N 470 -40 490 -40 {lab=VSS}
N 610 -120 630 -120 {lab=VDD}
N 610 -40 630 -40 {lab=VSS}
N 540 -80 560 -80 {lab=#net8}
N 20 -80 140 -80 {lab=CLK}
N 3240 -1700 3280 -1700 {lab=P_RES}
N 2080 -1880 2100 -1880 {lab=VDD}
N 2080 -1520 2100 -1520 {lab=VSS}
N 3170 -1740 3190 -1740 {lab=VDD}
N 3170 -1660 3190 -1660 {lab=VSS}
N 3240 -2300 3280 -2300 {lab=P_TX}
N 2080 -2280 2100 -2280 {lab=VDD}
N 2080 -1920 2100 -1920 {lab=VSS}
N 3170 -2340 3190 -2340 {lab=VDD}
N 3170 -2260 3190 -2260 {lab=VSS}
N 2080 -2680 2100 -2680 {lab=VDD}
N 2080 -2320 2100 -2320 {lab=VSS}
N 3240 -2900 3280 -2900 {lab=P_WRTN}
N 2080 -3080 2100 -3080 {lab=VDD}
N 2080 -2720 2100 -2720 {lab=VSS}
N 3170 -2940 3190 -2940 {lab=VDD}
N 3170 -2860 3190 -2860 {lab=VSS}
N 3240 -3300 3280 -3300 {lab=P_WRTS}
N 2080 -3480 2100 -3480 {lab=VDD}
N 2080 -3120 2100 -3120 {lab=VSS}
N 3170 -3340 3190 -3340 {lab=VDD}
N 3170 -3260 3190 -3260 {lab=VSS}
N 3240 -3700 3280 -3700 {lab=P_RDN_0}
N 2080 -3880 2100 -3880 {lab=VDD}
N 2080 -3520 2100 -3520 {lab=VSS}
N 3170 -3740 3190 -3740 {lab=VDD}
N 3170 -3660 3190 -3660 {lab=VSS}
N 3240 -4100 3280 -4100 {lab=P_RDN_1}
N 2080 -4280 2100 -4280 {lab=VDD}
N 2080 -3920 2100 -3920 {lab=VSS}
N 3170 -4140 3190 -4140 {lab=VDD}
N 3170 -4060 3190 -4060 {lab=VSS}
N 3240 -4500 3280 -4500 {lab=P_RDN_2}
N 2080 -4680 2100 -4680 {lab=VDD}
N 2080 -4320 2100 -4320 {lab=VSS}
N 3170 -4540 3190 -4540 {lab=VDD}
N 3170 -4460 3190 -4460 {lab=VSS}
N 3240 -4900 3280 -4900 {lab=P_RDN_3}
N 2080 -5080 2100 -5080 {lab=VDD}
N 2080 -4720 2100 -4720 {lab=VSS}
N 3170 -4940 3190 -4940 {lab=VDD}
N 3170 -4860 3190 -4860 {lab=VSS}
N 3240 -5300 3280 -5300 {lab=P_RDS_0}
N 2080 -5480 2100 -5480 {lab=VDD}
N 2080 -5120 2100 -5120 {lab=VSS}
N 3170 -5340 3190 -5340 {lab=VDD}
N 3170 -5260 3190 -5260 {lab=VSS}
N 3240 -5700 3280 -5700 {lab=P_RDS_1}
N 2080 -5880 2100 -5880 {lab=VDD}
N 2080 -5520 2100 -5520 {lab=VSS}
N 3170 -5740 3190 -5740 {lab=VDD}
N 3170 -5660 3190 -5660 {lab=VSS}
N 3240 -6100 3280 -6100 {lab=P_RDS_2}
N 2080 -6280 2100 -6280 {lab=VDD}
N 2080 -5920 2100 -5920 {lab=VSS}
N 3170 -6140 3190 -6140 {lab=VDD}
N 3170 -6060 3190 -6060 {lab=VSS}
N 3240 -6500 3280 -6500 {lab=P_RDS_3}
N 2080 -6680 2100 -6680 {lab=VDD}
N 2080 -6320 2100 -6320 {lab=VSS}
N 3170 -6540 3190 -6540 {lab=VDD}
N 3170 -6460 3190 -6460 {lab=VSS}
N 2310 -2360 2330 -2360 {lab=VDD}
N 2310 -2240 2330 -2240 {lab=VSS}
N 2220 -2500 2240 -2500 {lab=#net9}
N 2240 -2320 2260 -2320 {lab=#net9}
N 2220 -2100 2240 -2100 {lab=#net10}
N 2240 -2280 2260 -2280 {lab=#net10}
N 2390 -2300 3120 -2300 {lab=#net11}
N 2160 -7260 2160 -220 {lab=RES_O}
N 1500 -1840 2060 -1840 {lab=d1_b}
N 1520 -1820 2060 -1820 {lab=d2}
N 1560 -1800 2060 -1800 {lab=d4}
N 1620 -1780 2060 -1780 {lab=d8_b}
N 1660 -1760 2060 -1760 {lab=d16_b}
N 1700 -1740 2060 -1740 {lab=d32_b}
N 1740 -1720 2060 -1720 {lab=d64_b}
N 1480 -1680 2060 -1680 {lab=d1}
N 1520 -1660 2060 -1660 {lab=d2}
N 1560 -1640 2060 -1640 {lab=d4}
N 1600 -1620 2060 -1620 {lab=d8}
N 1660 -1600 2060 -1600 {lab=d16_b}
N 1700 -1580 2060 -1580 {lab=d32_b}
N 1740 -1560 2060 -1560 {lab=d64_b}
N 1500 -2240 2060 -2240 {lab=d1_b}
N 1520 -2220 2060 -2220 {lab=d2}
N 1560 -2200 2060 -2200 {lab=d4}
N 1620 -2180 2060 -2180 {lab=d8_b}
N 1660 -2160 2060 -2160 {lab=d16_b}
N 1700 -2140 2060 -2140 {lab=d32_b}
N 1740 -2120 2060 -2120 {lab=d64_b}
N 1500 -2080 2060 -2080 {lab=d1_b}
N 1540 -2060 2060 -2060 {lab=d2_b}
N 1560 -2040 2060 -2040 {lab=d4}
N 1600 -2020 2060 -2020 {lab=d8}
N 1660 -2000 2060 -2000 {lab=d16_b}
N 1700 -1980 2060 -1980 {lab=d32_b}
N 1740 -1960 2060 -1960 {lab=d64_b}
N 1720 -2520 2060 -2520 {lab=d64}
N 1680 -2540 2060 -2540 {lab=d32}
N 1660 -2560 2060 -2560 {lab=d16_b}
N 1600 -2580 2060 -2580 {lab=d8}
N 1580 -2600 2060 -2600 {lab=d4_b}
N 1520 -2620 2060 -2620 {lab=d2}
N 1480 -2640 2060 -2640 {lab=d1}
N 1720 -2360 2060 -2360 {lab=d64}
N 1680 -2380 2060 -2380 {lab=d32}
N 1640 -2400 2060 -2400 {lab=d16}
N 1620 -2420 2060 -2420 {lab=d8_b}
N 1560 -2440 2060 -2440 {lab=d4}
N 1540 -2460 2060 -2460 {lab=d2_b}
N 1500 -2480 2060 -2480 {lab=d1_b}
N 1740 -2920 2060 -2920 {lab=d64_b}
N 1680 -2940 2060 -2940 {lab=d32}
N 1640 -2960 2060 -2960 {lab=d16}
N 1600 -2980 2060 -2980 {lab=d8}
N 1580 -3000 2060 -3000 {lab=d4_b}
N 1540 -3020 2060 -3020 {lab=d2_b}
N 1480 -3040 2060 -3040 {lab=d1}
N 1740 -2760 2060 -2760 {lab=d64_b}
N 1680 -2780 2060 -2780 {lab=d32}
N 1640 -2800 2060 -2800 {lab=d16}
N 1600 -2820 2060 -2820 {lab=d8}
N 1560 -2840 2060 -2840 {lab=d4}
N 1540 -2860 2060 -2860 {lab=d2_b}
N 1500 -2880 2060 -2880 {lab=d1_b}
N 1680 -620 1740 -620 {lab=d64_b}
N 1540 -620 1600 -620 {lab=d32_b}
N 1600 -800 1600 -620 {lab=d32_b}
N 1400 -620 1460 -620 {lab=d16_b}
N 1460 -840 1460 -620 {lab=d16_b}
N 1260 -620 1320 -620 {lab=d8_b}
N 1320 -880 1320 -620 {lab=d8_b}
N 1120 -620 1180 -620 {lab=d4_b}
N 1180 -920 1180 -620 {lab=d4_b}
N 980 -620 1040 -620 {lab=d2_b}
N 1040 -960 1040 -620 {lab=d2_b}
N 840 -620 900 -620 {lab=d1_b}
N 900 -1000 900 -620 {lab=d1_b}
N 1720 -3320 2060 -3320 {lab=d64}
N 1680 -3340 2060 -3340 {lab=d32}
N 1640 -3360 2060 -3360 {lab=d16}
N 1600 -3380 2060 -3380 {lab=d8}
N 1580 -3400 2060 -3400 {lab=d4_b}
N 1540 -3420 2060 -3420 {lab=d2_b}
N 1480 -3440 2060 -3440 {lab=d1}
N 1500 -3280 2060 -3280 {lab=d1_b}
N 1540 -3260 2060 -3260 {lab=d2_b}
N 1560 -3240 2060 -3240 {lab=d4}
N 1600 -3220 2060 -3220 {lab=d8}
N 1640 -3200 2060 -3200 {lab=d16}
N 1680 -3180 2060 -3180 {lab=d32}
N 1720 -3160 2060 -3160 {lab=d64}
N 1480 -3840 2060 -3840 {lab=d1}
N 1720 -3720 2060 -3720 {lab=d64}
N 1700 -3740 2060 -3740 {lab=d32_b}
N 1660 -3760 2060 -3760 {lab=d16_b}
N 1620 -3780 2060 -3780 {lab=d8_b}
N 1580 -3800 2060 -3800 {lab=d4_b}
N 1540 -3820 2060 -3820 {lab=d2_b}
N 1480 -3680 2060 -3680 {lab=d1}
N 1540 -3660 2060 -3660 {lab=d2_b}
N 1560 -3640 2060 -3640 {lab=d4}
N 1600 -3620 2060 -3620 {lab=d8}
N 1660 -3600 2060 -3600 {lab=d16_b}
N 1700 -3580 2060 -3580 {lab=d32_b}
N 1720 -3560 2060 -3560 {lab=d64}
N 1500 -4240 2060 -4240 {lab=d1_b}
N 1520 -4220 2060 -4220 {lab=d2}
N 1560 -4200 2060 -4200 {lab=d4}
N 1600 -4180 2060 -4180 {lab=d8}
N 1660 -4160 2060 -4160 {lab=d16_b}
N 1700 -4140 2060 -4140 {lab=d32_b}
N 1720 -4120 2060 -4120 {lab=d64}
N 1500 -4080 2060 -4080 {lab=d1_b}
N 1520 -4060 2060 -4060 {lab=d2}
N 1580 -4040 2060 -4040 {lab=d4_b}
N 1600 -4020 2060 -4020 {lab=d8}
N 1640 -4000 2060 -4000 {lab=d16}
N 1700 -3980 2060 -3980 {lab=d32_b}
N 1720 -3960 2060 -3960 {lab=d64}
N 1480 -4640 2060 -4640 {lab=d1}
N 1520 -4620 2060 -4620 {lab=d2}
N 1580 -4600 2060 -4600 {lab=d4_b}
N 1600 -4580 2060 -4580 {lab=d8}
N 1640 -4560 2060 -4560 {lab=d16}
N 1700 -4540 2060 -4540 {lab=d32_b}
N 1720 -4520 2060 -4520 {lab=d64}
N 1480 -4480 2060 -4480 {lab=d1}
N 1520 -4460 2060 -4460 {lab=d2}
N 1560 -4440 2060 -4440 {lab=d4}
N 1620 -4420 2060 -4420 {lab=d8_b}
N 1660 -4400 2060 -4400 {lab=d16_b}
N 1720 -4360 2060 -4360 {lab=d64}
N 1680 -4380 2060 -4380 {lab=d32}
N 1500 -5040 2060 -5040 {lab=d1_b}
N 1540 -5020 2060 -5020 {lab=d2_b}
N 1580 -5000 2060 -5000 {lab=d4_b}
N 1600 -4980 2060 -4980 {lab=d8}
N 1660 -4960 2060 -4960 {lab=d16_b}
N 1680 -4940 2060 -4940 {lab=d32}
N 1720 -4920 2060 -4920 {lab=d64}
N 1500 -4880 2060 -4880 {lab=d1_b}
N 1540 -4860 2060 -4860 {lab=d2_b}
N 1560 -4840 2060 -4840 {lab=d4}
N 1620 -4820 2060 -4820 {lab=d8_b}
N 1640 -4800 2060 -4800 {lab=d16}
N 1680 -4780 2060 -4780 {lab=d32}
N 1720 -4760 2060 -4760 {lab=d64}
N 1480 -5440 2060 -5440 {lab=d1}
N 1540 -5420 2060 -5420 {lab=d2_b}
N 1580 -5400 2060 -5400 {lab=d4_b}
N 1620 -5380 2060 -5380 {lab=d8_b}
N 1660 -5360 2060 -5360 {lab=d16_b}
N 1700 -5340 2060 -5340 {lab=d32_b}
N 1740 -5320 2060 -5320 {lab=d64_b}
N 1480 -5280 2060 -5280 {lab=d1}
N 1540 -5260 2060 -5260 {lab=d2_b}
N 1560 -5240 2060 -5240 {lab=d4}
N 1600 -5220 2060 -5220 {lab=d8}
N 1660 -5200 2060 -5200 {lab=d16_b}
N 1700 -5180 2060 -5180 {lab=d32_b}
N 1740 -5160 2060 -5160 {lab=d64_b}
N 1500 -5840 2060 -5840 {lab=d1_b}
N 1520 -5820 2060 -5820 {lab=d2}
N 1560 -5800 2060 -5800 {lab=d4}
N 1600 -5780 2060 -5780 {lab=d8}
N 1660 -5760 2060 -5760 {lab=d16_b}
N 1700 -5740 2060 -5740 {lab=d32_b}
N 1740 -5720 2060 -5720 {lab=d64_b}
N 1500 -5680 2060 -5680 {lab=d1_b}
N 1520 -5660 2060 -5660 {lab=d2}
N 1580 -5640 2060 -5640 {lab=d4_b}
N 1600 -5620 2060 -5620 {lab=d8}
N 1640 -5600 2060 -5600 {lab=d16}
N 1700 -5580 2060 -5580 {lab=d32_b}
N 1740 -5560 2060 -5560 {lab=d64_b}
N 1480 -6240 2060 -6240 {lab=d1}
N 1520 -6220 2060 -6220 {lab=d2}
N 1580 -6200 2060 -6200 {lab=d4_b}
N 1600 -6180 2060 -6180 {lab=d8}
N 1640 -6160 2060 -6160 {lab=d16}
N 1700 -6140 2060 -6140 {lab=d32_b}
N 1740 -6120 2060 -6120 {lab=d64_b}
N 1480 -6080 2060 -6080 {lab=d1}
N 1520 -6060 2060 -6060 {lab=d2}
N 1560 -6040 2060 -6040 {lab=d4}
N 1620 -6020 2060 -6020 {lab=d8_b}
N 1660 -6000 2060 -6000 {lab=d16_b}
N 1680 -5980 2060 -5980 {lab=d32}
N 1740 -5960 2060 -5960 {lab=d64_b}
N 1500 -6640 2060 -6640 {lab=d1_b}
N 1540 -6620 2060 -6620 {lab=d2_b}
N 1580 -6600 2060 -6600 {lab=d4_b}
N 1600 -6580 2060 -6580 {lab=d8}
N 1660 -6560 2060 -6560 {lab=d16_b}
N 1680 -6540 2060 -6540 {lab=d32}
N 1740 -6520 2060 -6520 {lab=d64_b}
N 1500 -6480 2060 -6480 {lab=d1_b}
N 1540 -6460 2060 -6460 {lab=d2_b}
N 1560 -6440 2060 -6440 {lab=d4}
N 1620 -6420 2060 -6420 {lab=d8_b}
N 1640 -6400 2060 -6400 {lab=d16}
N 1680 -6380 2060 -6380 {lab=d32}
N 1740 -6360 2060 -6360 {lab=d64_b}
N 190 -260 210 -260 {lab=VDD}
N 190 -180 210 -180 {lab=VSS}
N 20 -220 140 -220 {lab=RES_B}
N 470 -260 490 -260 {lab=VDD}
N 470 -180 490 -180 {lab=VSS}
N 610 -260 630 -260 {lab=VDD}
N 610 -180 630 -180 {lab=VSS}
N 540 -220 560 -220 {lab=#net12}
N 260 -220 420 -220 {lab=#net13}
N 680 -220 3280 -220 {lab=RES_O}
N 790 -290 790 -220 {lab=RES_O}
N 930 -290 930 -220 {lab=RES_O}
N 1070 -290 1070 -220 {lab=RES_O}
N 1210 -290 1210 -220 {lab=RES_O}
N 1350 -290 1350 -220 {lab=RES_O}
N 1490 -290 1490 -220 {lab=RES_O}
N 1630 -290 1630 -220 {lab=RES_O}
N 3240 -6900 3280 -6900 {lab=HD}
N 2080 -7080 2100 -7080 {lab=VDD}
N 2080 -6720 2100 -6720 {lab=VSS}
N 3170 -6940 3190 -6940 {lab=VDD}
N 3170 -6860 3190 -6860 {lab=VSS}
N 1480 -7040 2060 -7040 {lab=d1}
N 1540 -7020 2060 -7020 {lab=d2_b}
N 1580 -7000 2060 -7000 {lab=d4_b}
N 1620 -6980 2060 -6980 {lab=d8_b}
N 1660 -6960 2060 -6960 {lab=d16_b}
N 1700 -6940 2060 -6940 {lab=d32_b}
N 1740 -6920 2060 -6920 {lab=d64_b}
N 1480 -6880 2060 -6880 {lab=d1}
N 1540 -6860 2060 -6860 {lab=d2_b}
N 1560 -6840 2060 -6840 {lab=d4}
N 1620 -6820 2060 -6820 {lab=d8_b}
N 1660 -6800 2060 -6800 {lab=d16_b}
N 1700 -6780 2060 -6780 {lab=d32_b}
N 1740 -6760 2060 -6760 {lab=d64_b}
N 1660 -360 1700 -360 {lab=#net14}
N 1700 -320 1740 -320 {lab=#net14}
N 1740 -390 1760 -390 {lab=VDD}
N 1740 -270 1760 -270 {lab=VSS}
N 1720 -360 1740 -360 {lab=ffout128}
N 1720 -420 1720 -360 {lab=ffout128}
N 1720 -420 1820 -420 {lab=ffout128}
N 1820 -420 1820 -320 {lab=ffout128}
N 1800 -320 1820 -320 {lab=ffout128}
N 1700 -360 1700 -320 {lab=#net14}
N 1820 -480 1820 -420 {lab=ffout128}
N 1780 -550 1780 -530 {lab=VDD}
N 1860 -550 1860 -530 {lab=VSS}
N 1820 -640 1820 -600 {lab=d128_b}
N 1780 -710 1780 -690 {lab=VDD}
N 1860 -710 1860 -690 {lab=VSS}
N 1770 -290 1770 -220 {lab=RES_O}
N 1800 -360 1840 -360 {lab=#net15}
N 1840 -320 1880 -320 {lab=#net15}
N 1880 -390 1900 -390 {lab=VDD}
N 1880 -270 1900 -270 {lab=VSS}
N 1860 -360 1880 -360 {lab=ffout256}
N 1860 -420 1860 -360 {lab=ffout256}
N 1860 -420 1960 -420 {lab=ffout256}
N 1960 -420 1960 -320 {lab=ffout256}
N 1940 -320 1960 -320 {lab=ffout256}
N 1840 -360 1840 -320 {lab=#net15}
N 1960 -480 1960 -420 {lab=ffout256}
N 1920 -550 1920 -530 {lab=VDD}
N 2000 -550 2000 -530 {lab=VSS}
N 1960 -640 1960 -600 {lab=d256_b}
N 1920 -710 1920 -690 {lab=VDD}
N 2000 -710 2000 -690 {lab=VSS}
N 2020 -7160 2020 -620 {lab=d256_b}
N 1910 -290 1910 -220 {lab=RES_O}
N 2000 -7180 2000 -780 {lab=d128_b}
N 2000 -7180 2260 -7180 {lab=d128_b}
N 2020 -7160 2260 -7160 {lab=d256_b}
N 2240 -7460 2240 -6900 {lab=#net16}
N 2240 -7140 2260 -7140 {lab=#net16}
N 2310 -7220 2330 -7220 {lab=VDD}
N 2310 -7100 2330 -7100 {lab=VSS}
N 3240 -7160 3280 -7160 {lab=VD}
N 3170 -7200 3190 -7200 {lab=VDD}
N 3170 -7120 3190 -7120 {lab=VSS}
N 2390 -7160 3120 -7160 {lab=#net17}
N 2310 -7380 2330 -7380 {lab=VDD}
N 2310 -7300 2330 -7300 {lab=VSS}
N 2140 -7340 2260 -7340 {lab=#net1}
N 2440 -7490 2460 -7490 {lab=VDD}
N 2440 -7370 2460 -7370 {lab=VSS}
N 2470 -7390 2470 -7260 {lab=RES_O}
N 2240 -7460 2440 -7460 {lab=#net16}
N 2380 -7340 2520 -7340 {lab=#net18}
N 2400 -7420 2400 -7340 {lab=#net18}
N 2400 -7420 2440 -7420 {lab=#net18}
N 2500 -7460 2700 -7460 {lab=#net19}
N 2160 -7260 2730 -7260 {lab=RES_O}
N 3030 -7520 3050 -7520 {lab=VDD}
N 3030 -7440 3050 -7440 {lab=VSS}
N 3170 -7520 3190 -7520 {lab=VDD}
N 3170 -7440 3190 -7440 {lab=VSS}
N 3100 -7480 3120 -7480 {lab=#net20}
N 3240 -7480 3280 -7480 {lab=VCLK}
N 190 -120 210 -120 {lab=VDD}
N 190 -40 210 -40 {lab=VSS}
N 330 -120 350 -120 {lab=VDD}
N 330 -40 350 -40 {lab=VSS}
N 260 -80 280 -80 {lab=#net21}
N 400 -80 420 -80 {lab=#net22}
N 1680 -780 1720 -780 {lab=d64}
N 1600 -800 1700 -800 {lab=d32_b}
N 1540 -820 1680 -820 {lab=d32}
N 1460 -840 1660 -840 {lab=d16_b}
N 1400 -860 1640 -860 {lab=d16}
N 1320 -880 1620 -880 {lab=d8_b}
N 1260 -900 1600 -900 {lab=d8}
N 1180 -920 1580 -920 {lab=d4_b}
N 1120 -940 1560 -940 {lab=d4}
N 1040 -960 1540 -960 {lab=d2_b}
N 980 -980 1520 -980 {lab=d2}
N 900 -1000 1500 -1000 {lab=d1_b}
N 840 -1020 1480 -1020 {lab=d1}
N 1820 -620 1880 -620 {lab=d128_b}
N 1880 -780 1880 -620 {lab=d128_b}
N 1880 -780 2000 -780 {lab=d128_b}
N 1960 -620 2020 -620 {lab=d256_b}
N 2570 -7380 2590 -7380 {lab=VDD}
N 2570 -7300 2590 -7300 {lab=VSS}
N 2700 -7490 2720 -7490 {lab=VDD}
N 2700 -7370 2720 -7370 {lab=VSS}
N 2730 -7390 2730 -7260 {lab=RES_O}
N 2640 -7340 2660 -7340 {lab=#net23}
N 2660 -7420 2660 -7340 {lab=#net23}
N 2660 -7420 2700 -7420 {lab=#net23}
N 2850 -7540 2870 -7540 {lab=VDD}
N 2850 -7420 2870 -7420 {lab=VSS}
N 2760 -7420 2780 -7420 {lab=#net24}
N 2780 -7460 2780 -7420 {lab=#net24}
N 2780 -7460 2800 -7460 {lab=#net24}
N 2660 -7520 2660 -7460 {lab=#net19}
N 2660 -7520 2780 -7520 {lab=#net19}
N 2780 -7520 2780 -7500 {lab=#net19}
N 2780 -7500 2800 -7500 {lab=#net19}
N 2930 -7480 2980 -7480 {lab=#net25}
N 2220 -6900 2240 -6900 {lab=#net16}
N 2220 -1300 3120 -1300 {lab=#net26}
N 2220 -1700 3120 -1700 {lab=#net27}
N 2240 -2500 2240 -2320 {lab=#net9}
N 2240 -2280 2240 -2100 {lab=#net10}
N 2220 -2900 3120 -2900 {lab=#net28}
N 2220 -3300 3120 -3300 {lab=#net29}
N 2220 -3700 3120 -3700 {lab=#net30}
N 2220 -4100 3120 -4100 {lab=#net31}
N 2220 -4500 3120 -4500 {lab=#net32}
N 2220 -4900 3120 -4900 {lab=#net33}
N 2220 -5300 3120 -5300 {lab=#net34}
N 2220 -5700 3120 -5700 {lab=#net35}
N 2220 -6100 3120 -6100 {lab=#net36}
N 2220 -6500 3120 -6500 {lab=#net37}
N 2220 -6900 3120 -6900 {lab=#net16}
C {devices/iopin.sym} 20 -40 0 1 {name=p1 lab=VDD}
C {devices/iopin.sym} 20 -20 0 1 {name=p2 lab=VSS}
C {devices/ipin.sym} 20 -80 0 0 {name=p3 lab=CLK}
C {devices/opin.sym} 3280 -1300 0 0 {name=p4 lab=P_SEL}
C {devices/opin.sym} 3280 -1700 0 0 {name=p5 lab=P_RES}
C {devices/opin.sym} 3280 -2300 0 0 {name=p6 lab=P_TX}
C {devices/opin.sym} 3280 -2900 0 0 {name=p7 lab=P_WRTN}
C {devices/opin.sym} 3280 -3300 0 0 {name=p8 lab=P_WRTS}
C {devices/opin.sym} 3280 -3700 0 0 {name=p9 lab=P_RDN_0}
C {devices/opin.sym} 3280 -4100 0 0 {name=p10 lab=P_RDN_1}
C {devices/opin.sym} 3280 -4500 0 0 {name=p11 lab=P_RDN_2}
C {devices/opin.sym} 3280 -4900 0 0 {name=p12 lab=P_RDN_3}
C {devices/opin.sym} 3280 -5300 0 0 {name=p13 lab=P_RDS_0}
C {devices/opin.sym} 3280 -5700 0 0 {name=p14 lab=P_RDS_1}
C {devices/opin.sym} 3280 -6100 0 0 {name=p15 lab=P_RDS_2}
C {devices/opin.sym} 3280 -6500 0 0 {name=p16 lab=P_RDS_3}
C {TR-1um_5_stdcell/DFFR.sym} 790 -330 0 0 {name=x1}
C {devices/lab_wire.sym} 770 -390 0 1 {name=p18 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 770 -270 2 0 {name=p19 sig_type=std_logic lab=VSS}
C {devices/ipin.sym} 20 -220 0 0 {name=p21 lab=RES_B}
C {TR-1um_5_stdcell/DFFR.sym} 930 -330 0 0 {name=x2}
C {devices/lab_wire.sym} 910 -390 0 1 {name=p22 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 910 -270 2 0 {name=p23 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/DFFR.sym} 1070 -330 0 0 {name=x3}
C {devices/lab_wire.sym} 1050 -390 0 1 {name=p20 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1050 -270 2 0 {name=p24 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/DFFR.sym} 1210 -330 0 0 {name=x4}
C {devices/lab_wire.sym} 1190 -390 0 1 {name=p25 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1190 -270 2 0 {name=p26 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/DFFR.sym} 1350 -330 0 0 {name=x5}
C {devices/lab_wire.sym} 1330 -390 0 1 {name=p27 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1330 -270 2 0 {name=p28 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/DFFR.sym} 1490 -330 0 0 {name=x6}
C {devices/lab_wire.sym} 1470 -390 0 1 {name=p29 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1470 -270 2 0 {name=p30 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/DFFR.sym} 1630 -330 0 0 {name=x7}
C {devices/lab_wire.sym} 1610 -390 0 1 {name=p31 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1610 -270 2 0 {name=p32 sig_type=std_logic lab=VSS}
C {devices/opin.sym} 3280 -220 0 0 {name=p37 lab=RES_O}
C {TR-1um_5_stdcell/INV_X1.sym} 840 -500 3 0 {name=x8}
C {devices/lab_wire.sym} 800 -540 3 0 {name=p33 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -540 1 1 {name=p34 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/INV_X1.sym} 840 -660 3 0 {name=x9}
C {devices/lab_wire.sym} 800 -700 3 0 {name=p35 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 880 -700 1 1 {name=p36 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/INV_X1.sym} 980 -500 3 0 {name=x10}
C {devices/lab_wire.sym} 940 -540 3 0 {name=p38 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1020 -540 1 1 {name=p39 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/INV_X1.sym} 980 -660 3 0 {name=x11}
C {devices/lab_wire.sym} 940 -700 3 0 {name=p40 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1020 -700 1 1 {name=p41 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/INV_X1.sym} 1120 -500 3 0 {name=x12}
C {devices/lab_wire.sym} 1080 -540 3 0 {name=p42 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1160 -540 1 1 {name=p43 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/INV_X1.sym} 1120 -660 3 0 {name=x13}
C {devices/lab_wire.sym} 1080 -700 3 0 {name=p44 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1160 -700 1 1 {name=p45 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/INV_X1.sym} 1260 -500 3 0 {name=x14}
C {devices/lab_wire.sym} 1220 -540 3 0 {name=p46 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1300 -540 1 1 {name=p47 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/INV_X1.sym} 1260 -660 3 0 {name=x15}
C {devices/lab_wire.sym} 1220 -700 3 0 {name=p48 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1300 -700 1 1 {name=p49 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/INV_X1.sym} 1400 -500 3 0 {name=x16}
C {devices/lab_wire.sym} 1360 -540 3 0 {name=p50 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1440 -540 1 1 {name=p51 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/INV_X1.sym} 1400 -660 3 0 {name=x17}
C {devices/lab_wire.sym} 1360 -700 3 0 {name=p52 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1440 -700 1 1 {name=p53 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/INV_X1.sym} 1540 -500 3 0 {name=x18}
C {devices/lab_wire.sym} 1500 -540 3 0 {name=p54 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1580 -540 1 1 {name=p55 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/INV_X1.sym} 1540 -660 3 0 {name=x19}
C {devices/lab_wire.sym} 1500 -700 3 0 {name=p56 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1580 -700 1 1 {name=p57 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/INV_X1.sym} 1680 -500 3 0 {name=x20}
C {devices/lab_wire.sym} 1640 -540 3 0 {name=p58 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1720 -540 1 1 {name=p59 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/INV_X1.sym} 1680 -660 3 0 {name=x21}
C {devices/lab_wire.sym} 1640 -700 3 0 {name=p60 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1720 -700 1 1 {name=p61 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1480 -1080 3 1 {name=p62 sig_type=std_logic lab=d1}
C {devices/lab_wire.sym} 1520 -1080 3 1 {name=p63 sig_type=std_logic lab=d2}
C {devices/lab_wire.sym} 1560 -1080 3 1 {name=p64 sig_type=std_logic lab=d4}
C {devices/lab_wire.sym} 1600 -1080 3 1 {name=p65 sig_type=std_logic lab=d8}
C {devices/lab_wire.sym} 1640 -1080 3 1 {name=p66 sig_type=std_logic lab=d16}
C {devices/lab_wire.sym} 1680 -1080 3 1 {name=p67 sig_type=std_logic lab=d32}
C {devices/lab_wire.sym} 1720 -1080 3 1 {name=p68 sig_type=std_logic lab=d64}
C {devices/lab_wire.sym} 1500 -1080 3 1 {name=p69 sig_type=std_logic lab=d1_b}
C {devices/lab_wire.sym} 1540 -1080 3 1 {name=p70 sig_type=std_logic lab=d2_b}
C {devices/lab_wire.sym} 1580 -1080 3 1 {name=p71 sig_type=std_logic lab=d4_b}
C {devices/lab_wire.sym} 1620 -1080 3 1 {name=p72 sig_type=std_logic lab=d8_b}
C {devices/lab_wire.sym} 1660 -1080 3 1 {name=p73 sig_type=std_logic lab=d16_b}
C {devices/lab_wire.sym} 1700 -1080 3 1 {name=p74 sig_type=std_logic lab=d32_b}
C {devices/lab_wire.sym} 1740 -1080 3 1 {name=p75 sig_type=std_logic lab=d64_b}
C {2026_imager/pulsegen.sym} 2140 -1300 0 0 {name=x22}
C {devices/lab_wire.sym} 2090 -1480 0 0 {name=p17 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2090 -1120 2 1 {name=p76 sig_type=std_logic lab=VSS}
C {2026_imager/buf_x16.sym} 3170 -1300 0 0 {name=x23}
C {devices/lab_wire.sym} 3180 -1340 0 0 {name=p77 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3180 -1260 2 1 {name=p78 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 480 -120 0 0 {name=p79 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 480 -40 2 1 {name=p80 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 620 -120 0 0 {name=p81 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 620 -40 2 1 {name=p82 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/INV_X4.sym} 440 -80 0 0 {name=x25}
C {2026_imager/pulsegen.sym} 2140 -1700 0 0 {name=x26}
C {devices/lab_wire.sym} 2090 -1880 0 0 {name=p84 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2090 -1520 2 1 {name=p85 sig_type=std_logic lab=VSS}
C {2026_imager/buf_x16.sym} 3170 -1700 0 0 {name=x27}
C {devices/lab_wire.sym} 3180 -1740 0 0 {name=p86 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3180 -1660 2 1 {name=p87 sig_type=std_logic lab=VSS}
C {2026_imager/pulsegen.sym} 2140 -2100 0 0 {name=x28}
C {devices/lab_wire.sym} 2090 -2280 0 0 {name=p89 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2090 -1920 2 1 {name=p90 sig_type=std_logic lab=VSS}
C {2026_imager/buf_x16.sym} 3170 -2300 0 0 {name=x29}
C {devices/lab_wire.sym} 3180 -2340 0 0 {name=p91 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3180 -2260 2 1 {name=p92 sig_type=std_logic lab=VSS}
C {2026_imager/pulsegen.sym} 2140 -2500 0 0 {name=x30}
C {devices/lab_wire.sym} 2090 -2680 0 0 {name=p94 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2090 -2320 2 1 {name=p95 sig_type=std_logic lab=VSS}
C {2026_imager/pulsegen.sym} 2140 -2900 0 0 {name=x32}
C {devices/lab_wire.sym} 2090 -3080 0 0 {name=p99 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2090 -2720 2 1 {name=p100 sig_type=std_logic lab=VSS}
C {2026_imager/buf_x16.sym} 3170 -2900 0 0 {name=x33}
C {devices/lab_wire.sym} 3180 -2940 0 0 {name=p101 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3180 -2860 2 1 {name=p102 sig_type=std_logic lab=VSS}
C {2026_imager/pulsegen.sym} 2140 -3300 0 0 {name=x34}
C {devices/lab_wire.sym} 2090 -3480 0 0 {name=p104 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2090 -3120 2 1 {name=p105 sig_type=std_logic lab=VSS}
C {2026_imager/buf_x16.sym} 3170 -3300 0 0 {name=x35}
C {devices/lab_wire.sym} 3180 -3340 0 0 {name=p106 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3180 -3260 2 1 {name=p107 sig_type=std_logic lab=VSS}
C {2026_imager/pulsegen.sym} 2140 -3700 0 0 {name=x36}
C {devices/lab_wire.sym} 2090 -3880 0 0 {name=p109 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2090 -3520 2 1 {name=p110 sig_type=std_logic lab=VSS}
C {2026_imager/buf_x16.sym} 3170 -3700 0 0 {name=x37}
C {devices/lab_wire.sym} 3180 -3740 0 0 {name=p111 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3180 -3660 2 1 {name=p112 sig_type=std_logic lab=VSS}
C {2026_imager/pulsegen.sym} 2140 -4100 0 0 {name=x38}
C {devices/lab_wire.sym} 2090 -4280 0 0 {name=p114 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2090 -3920 2 1 {name=p115 sig_type=std_logic lab=VSS}
C {2026_imager/buf_x16.sym} 3170 -4100 0 0 {name=x39}
C {devices/lab_wire.sym} 3180 -4140 0 0 {name=p116 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3180 -4060 2 1 {name=p117 sig_type=std_logic lab=VSS}
C {2026_imager/pulsegen.sym} 2140 -4500 0 0 {name=x40}
C {devices/lab_wire.sym} 2090 -4680 0 0 {name=p119 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2090 -4320 2 1 {name=p120 sig_type=std_logic lab=VSS}
C {2026_imager/buf_x16.sym} 3170 -4500 0 0 {name=x41}
C {devices/lab_wire.sym} 3180 -4540 0 0 {name=p121 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3180 -4460 2 1 {name=p122 sig_type=std_logic lab=VSS}
C {2026_imager/pulsegen.sym} 2140 -4900 0 0 {name=x42}
C {devices/lab_wire.sym} 2090 -5080 0 0 {name=p124 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2090 -4720 2 1 {name=p125 sig_type=std_logic lab=VSS}
C {2026_imager/buf_x16.sym} 3170 -4900 0 0 {name=x43}
C {devices/lab_wire.sym} 3180 -4940 0 0 {name=p126 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3180 -4860 2 1 {name=p127 sig_type=std_logic lab=VSS}
C {2026_imager/pulsegen.sym} 2140 -5300 0 0 {name=x44}
C {devices/lab_wire.sym} 2090 -5480 0 0 {name=p129 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2090 -5120 2 1 {name=p130 sig_type=std_logic lab=VSS}
C {2026_imager/buf_x16.sym} 3170 -5300 0 0 {name=x45}
C {devices/lab_wire.sym} 3180 -5340 0 0 {name=p131 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3180 -5260 2 1 {name=p132 sig_type=std_logic lab=VSS}
C {2026_imager/pulsegen.sym} 2140 -5700 0 0 {name=x46}
C {devices/lab_wire.sym} 2090 -5880 0 0 {name=p134 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2090 -5520 2 1 {name=p135 sig_type=std_logic lab=VSS}
C {2026_imager/buf_x16.sym} 3170 -5700 0 0 {name=x47}
C {devices/lab_wire.sym} 3180 -5740 0 0 {name=p136 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3180 -5660 2 1 {name=p137 sig_type=std_logic lab=VSS}
C {2026_imager/pulsegen.sym} 2140 -6100 0 0 {name=x48}
C {devices/lab_wire.sym} 2090 -6280 0 0 {name=p139 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2090 -5920 2 1 {name=p140 sig_type=std_logic lab=VSS}
C {2026_imager/buf_x16.sym} 3170 -6100 0 0 {name=x49}
C {devices/lab_wire.sym} 3180 -6140 0 0 {name=p141 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3180 -6060 2 1 {name=p142 sig_type=std_logic lab=VSS}
C {2026_imager/pulsegen.sym} 2140 -6500 0 0 {name=x50}
C {devices/lab_wire.sym} 2090 -6680 0 0 {name=p144 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2090 -6320 2 1 {name=p145 sig_type=std_logic lab=VSS}
C {2026_imager/buf_x16.sym} 3170 -6500 0 0 {name=x51}
C {devices/lab_wire.sym} 3180 -6540 0 0 {name=p146 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3180 -6460 2 1 {name=p147 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/OR2.sym} 2280 -2300 0 0 {name=x52}
C {devices/lab_wire.sym} 2320 -2360 2 0 {name=p83 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2320 -2240 0 1 {name=p88 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 200 -260 0 0 {name=p93 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 200 -180 2 1 {name=p96 sig_type=std_logic lab=VSS}
C {2026_imager/schmitt_trigger.sym} 190 -220 0 0 {name=x31}
C {devices/lab_wire.sym} 480 -260 0 0 {name=p103 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 480 -180 2 1 {name=p108 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 620 -260 0 0 {name=p113 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 620 -180 2 1 {name=p118 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/INV_X4.sym} 440 -220 0 0 {name=x55}
C {devices/opin.sym} 3280 -6900 0 0 {name=p123 lab=HD}
C {2026_imager/pulsegen.sym} 2140 -6900 0 0 {name=x56}
C {devices/lab_wire.sym} 2090 -7080 0 0 {name=p128 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2090 -6720 2 1 {name=p133 sig_type=std_logic lab=VSS}
C {2026_imager/buf_x16.sym} 3170 -6900 0 0 {name=x57}
C {devices/lab_wire.sym} 3180 -6940 0 0 {name=p138 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3180 -6860 2 1 {name=p143 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/DFFR.sym} 1770 -330 0 0 {name=x58}
C {devices/lab_wire.sym} 1750 -390 0 1 {name=p148 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1750 -270 2 0 {name=p149 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/INV_X1.sym} 1820 -500 3 0 {name=x59}
C {devices/lab_wire.sym} 1780 -540 3 0 {name=p150 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1860 -540 1 1 {name=p151 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/INV_X1.sym} 1820 -660 3 0 {name=x60}
C {devices/lab_wire.sym} 1780 -700 3 0 {name=p152 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1860 -700 1 1 {name=p153 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/DFFR.sym} 1910 -330 0 0 {name=x61}
C {devices/lab_wire.sym} 1890 -390 0 1 {name=p154 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1890 -270 2 0 {name=p155 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/INV_X1.sym} 1960 -500 3 0 {name=x62}
C {devices/lab_wire.sym} 1920 -540 3 0 {name=p156 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2000 -540 1 1 {name=p157 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/INV_X1.sym} 1960 -660 3 0 {name=x63}
C {devices/lab_wire.sym} 1920 -700 3 0 {name=p158 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2000 -700 1 1 {name=p159 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2000 -7100 3 1 {name=p160 sig_type=std_logic lab=d128_b}
C {devices/lab_wire.sym} 2020 -7100 3 1 {name=p161 sig_type=std_logic lab=d256_b}
C {TR-1um_5_stdcell/AND3_X1.sym} 2280 -7160 0 0 {name=x64}
C {devices/lab_wire.sym} 2320 -7220 0 0 {name=p162 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2320 -7100 2 1 {name=p163 sig_type=std_logic lab=VSS}
C {devices/opin.sym} 3280 -7160 0 0 {name=p164 lab=VD}
C {2026_imager/buf_x16.sym} 3170 -7160 0 0 {name=x65}
C {devices/lab_wire.sym} 3180 -7200 0 0 {name=p165 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3180 -7120 2 1 {name=p166 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/INV_X1.sym} 2280 -7340 0 0 {name=x66}
C {devices/lab_wire.sym} 2320 -7380 0 0 {name=p167 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2320 -7300 2 1 {name=p168 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/DFFR.sym} 2470 -7430 0 0 {name=x67}
C {devices/opin.sym} 3280 -7480 0 0 {name=p169 lab=VCLK}
C {TR-1um_5_stdcell/INV_X1.sym} 3000 -7480 0 0 {name=x68}
C {devices/lab_wire.sym} 3040 -7520 0 0 {name=p170 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3040 -7440 2 1 {name=p171 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3180 -7520 0 0 {name=p172 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3180 -7440 2 1 {name=p173 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/INV_X4.sym} 3140 -7480 0 0 {name=x69}
C {TR-1um_5_stdcell/INV_X1.sym} 160 -80 0 0 {name=x70}
C {devices/lab_wire.sym} 200 -120 0 0 {name=p174 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 200 -40 2 1 {name=p175 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/INV_X1.sym} 300 -80 0 0 {name=x71}
C {devices/lab_wire.sym} 340 -120 0 0 {name=p176 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 340 -40 2 1 {name=p177 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/INV_X16.sym} 580 -220 0 0 {name=x24}
C {TR-1um_5_stdcell/INV_X16.sym} 580 -80 0 0 {name=x54}
C {devices/lab_wire.sym} 820 -420 0 0 {name=p97 sig_type=std_logic lab=ffout1}
C {devices/lab_wire.sym} 960 -420 0 0 {name=p98 sig_type=std_logic lab=ffout2}
C {devices/lab_wire.sym} 1100 -420 0 0 {name=p178 sig_type=std_logic lab=ffout4}
C {devices/lab_wire.sym} 1240 -420 0 0 {name=p179 sig_type=std_logic lab=ffout8}
C {devices/lab_wire.sym} 1380 -420 0 0 {name=p180 sig_type=std_logic lab=ffout16}
C {devices/lab_wire.sym} 1520 -420 0 0 {name=p181 sig_type=std_logic lab=ffout32}
C {devices/lab_wire.sym} 1660 -420 0 0 {name=p182 sig_type=std_logic lab=ffout64}
C {devices/lab_wire.sym} 1800 -420 0 0 {name=p183 sig_type=std_logic lab=ffout128}
C {devices/lab_wire.sym} 1940 -420 0 0 {name=p184 sig_type=std_logic lab=ffout256}
C {devices/lab_wire.sym} 2450 -7490 0 0 {name=p187 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2450 -7370 2 1 {name=p188 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/INV_X1.sym} 2540 -7340 0 0 {name=x72}
C {devices/lab_wire.sym} 2580 -7380 0 0 {name=p189 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2580 -7300 2 1 {name=p190 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/DFFR.sym} 2730 -7430 0 0 {name=x73}
C {devices/lab_wire.sym} 2710 -7490 0 0 {name=p191 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2710 -7370 2 1 {name=p192 sig_type=std_logic lab=VSS}
C {TR-1um_5_stdcell/AND2_X1.sym} 2820 -7480 0 0 {name=x74}
C {devices/lab_wire.sym} 2860 -7540 0 0 {name=p193 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2860 -7420 2 1 {name=p194 sig_type=std_logic lab=VSS}
