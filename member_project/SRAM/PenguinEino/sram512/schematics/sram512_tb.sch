v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
E {}
T {SRAM512 | 16 x 32 | 7-pin serial interface | 5 V} -1100 -1000 0 0 0.55 0.55 {}
C {sram512_array.sym} 4000 0 0 0 {name=xarray}
C {sram512_row_decoder.sym} 300 0 0 0 {name=xrow}
N 460 -300 780 -300 {lab=WL0}
C {devices/lab_wire.sym} 620 -300 0 0 {name=l10 lab=WL0}
N 460 -260 780 -260 {lab=WL1}
C {devices/lab_wire.sym} 620 -260 0 0 {name=l12 lab=WL1}
N 460 -220 780 -220 {lab=WL2}
C {devices/lab_wire.sym} 620 -220 0 0 {name=l14 lab=WL2}
N 460 -180 780 -180 {lab=WL3}
C {devices/lab_wire.sym} 620 -180 0 0 {name=l16 lab=WL3}
N 460 -140 780 -140 {lab=WL4}
C {devices/lab_wire.sym} 620 -140 0 0 {name=l18 lab=WL4}
N 460 -100 780 -100 {lab=WL5}
C {devices/lab_wire.sym} 620 -100 0 0 {name=l20 lab=WL5}
N 460 -60 780 -60 {lab=WL6}
C {devices/lab_wire.sym} 620 -60 0 0 {name=l22 lab=WL6}
N 460 -20 780 -20 {lab=WL7}
C {devices/lab_wire.sym} 620 -20 0 0 {name=l24 lab=WL7}
N 460 20 780 20 {lab=WL8}
C {devices/lab_wire.sym} 620 20 0 0 {name=l26 lab=WL8}
N 460 60 780 60 {lab=WL9}
C {devices/lab_wire.sym} 620 60 0 0 {name=l28 lab=WL9}
N 460 100 780 100 {lab=WL10}
C {devices/lab_wire.sym} 620 100 0 0 {name=l30 lab=WL10}
N 460 140 780 140 {lab=WL11}
C {devices/lab_wire.sym} 620 140 0 0 {name=l32 lab=WL11}
N 460 180 780 180 {lab=WL12}
C {devices/lab_wire.sym} 620 180 0 0 {name=l34 lab=WL12}
N 460 220 780 220 {lab=WL13}
C {devices/lab_wire.sym} 620 220 0 0 {name=l36 lab=WL13}
N 460 260 780 260 {lab=WL14}
C {devices/lab_wire.sym} 620 260 0 0 {name=l38 lab=WL14}
N 460 300 780 300 {lab=WL15}
C {devices/lab_wire.sym} 620 300 0 0 {name=l40 lab=WL15}
C {sram512_column.sym} 900 1300 0 0 {name=xcol0}
N 850 720 850 1140 {lab=BL0}
C {devices/lab_wire.sym} 850 940 0 0 {name=l43 lab=BL0}
N 950 720 950 1140 {lab=BLB0}
C {devices/lab_wire.sym} 950 940 0 0 {name=l45 lab=BLB0}
N 850 1460 850 1560 {lab=Y}
N 950 1460 950 1600 {lab=YB}
C {sram512_column.sym} 1100 1300 0 0 {name=xcol1}
N 1050 720 1050 1140 {lab=BL1}
C {devices/lab_wire.sym} 1050 940 0 0 {name=l50 lab=BL1}
N 1150 720 1150 1140 {lab=BLB1}
C {devices/lab_wire.sym} 1150 940 0 0 {name=l52 lab=BLB1}
N 1050 1460 1050 1560 {lab=Y}
N 1150 1460 1150 1600 {lab=YB}
C {sram512_column.sym} 1300 1300 0 0 {name=xcol2}
N 1250 720 1250 1140 {lab=BL2}
C {devices/lab_wire.sym} 1250 940 0 0 {name=l57 lab=BL2}
N 1350 720 1350 1140 {lab=BLB2}
C {devices/lab_wire.sym} 1350 940 0 0 {name=l59 lab=BLB2}
N 1250 1460 1250 1560 {lab=Y}
N 1350 1460 1350 1600 {lab=YB}
C {sram512_column.sym} 1500 1300 0 0 {name=xcol3}
N 1450 720 1450 1140 {lab=BL3}
C {devices/lab_wire.sym} 1450 940 0 0 {name=l64 lab=BL3}
N 1550 720 1550 1140 {lab=BLB3}
C {devices/lab_wire.sym} 1550 940 0 0 {name=l66 lab=BLB3}
N 1450 1460 1450 1560 {lab=Y}
N 1550 1460 1550 1600 {lab=YB}
C {sram512_column.sym} 1700 1300 0 0 {name=xcol4}
N 1650 720 1650 1140 {lab=BL4}
C {devices/lab_wire.sym} 1650 940 0 0 {name=l71 lab=BL4}
N 1750 720 1750 1140 {lab=BLB4}
C {devices/lab_wire.sym} 1750 940 0 0 {name=l73 lab=BLB4}
N 1650 1460 1650 1560 {lab=Y}
N 1750 1460 1750 1600 {lab=YB}
C {sram512_column.sym} 1900 1300 0 0 {name=xcol5}
N 1850 720 1850 1140 {lab=BL5}
C {devices/lab_wire.sym} 1850 940 0 0 {name=l78 lab=BL5}
N 1950 720 1950 1140 {lab=BLB5}
C {devices/lab_wire.sym} 1950 940 0 0 {name=l80 lab=BLB5}
N 1850 1460 1850 1560 {lab=Y}
N 1950 1460 1950 1600 {lab=YB}
C {sram512_column.sym} 2100 1300 0 0 {name=xcol6}
N 2050 720 2050 1140 {lab=BL6}
C {devices/lab_wire.sym} 2050 940 0 0 {name=l85 lab=BL6}
N 2150 720 2150 1140 {lab=BLB6}
C {devices/lab_wire.sym} 2150 940 0 0 {name=l87 lab=BLB6}
N 2050 1460 2050 1560 {lab=Y}
N 2150 1460 2150 1600 {lab=YB}
C {sram512_column.sym} 2300 1300 0 0 {name=xcol7}
N 2250 720 2250 1140 {lab=BL7}
C {devices/lab_wire.sym} 2250 940 0 0 {name=l92 lab=BL7}
N 2350 720 2350 1140 {lab=BLB7}
C {devices/lab_wire.sym} 2350 940 0 0 {name=l94 lab=BLB7}
N 2250 1460 2250 1560 {lab=Y}
N 2350 1460 2350 1600 {lab=YB}
C {sram512_column.sym} 2500 1300 0 0 {name=xcol8}
N 2450 720 2450 1140 {lab=BL8}
C {devices/lab_wire.sym} 2450 940 0 0 {name=l99 lab=BL8}
N 2550 720 2550 1140 {lab=BLB8}
C {devices/lab_wire.sym} 2550 940 0 0 {name=l101 lab=BLB8}
N 2450 1460 2450 1560 {lab=Y}
N 2550 1460 2550 1600 {lab=YB}
C {sram512_column.sym} 2700 1300 0 0 {name=xcol9}
N 2650 720 2650 1140 {lab=BL9}
C {devices/lab_wire.sym} 2650 940 0 0 {name=l106 lab=BL9}
N 2750 720 2750 1140 {lab=BLB9}
C {devices/lab_wire.sym} 2750 940 0 0 {name=l108 lab=BLB9}
N 2650 1460 2650 1560 {lab=Y}
N 2750 1460 2750 1600 {lab=YB}
C {sram512_column.sym} 2900 1300 0 0 {name=xcol10}
N 2850 720 2850 1140 {lab=BL10}
C {devices/lab_wire.sym} 2850 940 0 0 {name=l113 lab=BL10}
N 2950 720 2950 1140 {lab=BLB10}
C {devices/lab_wire.sym} 2950 940 0 0 {name=l115 lab=BLB10}
N 2850 1460 2850 1560 {lab=Y}
N 2950 1460 2950 1600 {lab=YB}
C {sram512_column.sym} 3100 1300 0 0 {name=xcol11}
N 3050 720 3050 1140 {lab=BL11}
C {devices/lab_wire.sym} 3050 940 0 0 {name=l120 lab=BL11}
N 3150 720 3150 1140 {lab=BLB11}
C {devices/lab_wire.sym} 3150 940 0 0 {name=l122 lab=BLB11}
N 3050 1460 3050 1560 {lab=Y}
N 3150 1460 3150 1600 {lab=YB}
C {sram512_column.sym} 3300 1300 0 0 {name=xcol12}
N 3250 720 3250 1140 {lab=BL12}
C {devices/lab_wire.sym} 3250 940 0 0 {name=l127 lab=BL12}
N 3350 720 3350 1140 {lab=BLB12}
C {devices/lab_wire.sym} 3350 940 0 0 {name=l129 lab=BLB12}
N 3250 1460 3250 1560 {lab=Y}
N 3350 1460 3350 1600 {lab=YB}
C {sram512_column.sym} 3500 1300 0 0 {name=xcol13}
N 3450 720 3450 1140 {lab=BL13}
C {devices/lab_wire.sym} 3450 940 0 0 {name=l134 lab=BL13}
N 3550 720 3550 1140 {lab=BLB13}
C {devices/lab_wire.sym} 3550 940 0 0 {name=l136 lab=BLB13}
N 3450 1460 3450 1560 {lab=Y}
N 3550 1460 3550 1600 {lab=YB}
C {sram512_column.sym} 3700 1300 0 0 {name=xcol14}
N 3650 720 3650 1140 {lab=BL14}
C {devices/lab_wire.sym} 3650 940 0 0 {name=l141 lab=BL14}
N 3750 720 3750 1140 {lab=BLB14}
C {devices/lab_wire.sym} 3750 940 0 0 {name=l143 lab=BLB14}
N 3650 1460 3650 1560 {lab=Y}
N 3750 1460 3750 1600 {lab=YB}
C {sram512_column.sym} 3900 1300 0 0 {name=xcol15}
N 3850 720 3850 1140 {lab=BL15}
C {devices/lab_wire.sym} 3850 940 0 0 {name=l148 lab=BL15}
N 3950 720 3950 1140 {lab=BLB15}
C {devices/lab_wire.sym} 3950 940 0 0 {name=l150 lab=BLB15}
N 3850 1460 3850 1560 {lab=Y}
N 3950 1460 3950 1600 {lab=YB}
C {sram512_column.sym} 4100 1300 0 0 {name=xcol16}
N 4050 720 4050 1140 {lab=BL16}
C {devices/lab_wire.sym} 4050 940 0 0 {name=l155 lab=BL16}
N 4150 720 4150 1140 {lab=BLB16}
C {devices/lab_wire.sym} 4150 940 0 0 {name=l157 lab=BLB16}
N 4050 1460 4050 1560 {lab=Y}
N 4150 1460 4150 1600 {lab=YB}
C {sram512_column.sym} 4300 1300 0 0 {name=xcol17}
N 4250 720 4250 1140 {lab=BL17}
C {devices/lab_wire.sym} 4250 940 0 0 {name=l162 lab=BL17}
N 4350 720 4350 1140 {lab=BLB17}
C {devices/lab_wire.sym} 4350 940 0 0 {name=l164 lab=BLB17}
N 4250 1460 4250 1560 {lab=Y}
N 4350 1460 4350 1600 {lab=YB}
C {sram512_column.sym} 4500 1300 0 0 {name=xcol18}
N 4450 720 4450 1140 {lab=BL18}
C {devices/lab_wire.sym} 4450 940 0 0 {name=l169 lab=BL18}
N 4550 720 4550 1140 {lab=BLB18}
C {devices/lab_wire.sym} 4550 940 0 0 {name=l171 lab=BLB18}
N 4450 1460 4450 1560 {lab=Y}
N 4550 1460 4550 1600 {lab=YB}
C {sram512_column.sym} 4700 1300 0 0 {name=xcol19}
N 4650 720 4650 1140 {lab=BL19}
C {devices/lab_wire.sym} 4650 940 0 0 {name=l176 lab=BL19}
N 4750 720 4750 1140 {lab=BLB19}
C {devices/lab_wire.sym} 4750 940 0 0 {name=l178 lab=BLB19}
N 4650 1460 4650 1560 {lab=Y}
N 4750 1460 4750 1600 {lab=YB}
C {sram512_column.sym} 4900 1300 0 0 {name=xcol20}
N 4850 720 4850 1140 {lab=BL20}
C {devices/lab_wire.sym} 4850 940 0 0 {name=l183 lab=BL20}
N 4950 720 4950 1140 {lab=BLB20}
C {devices/lab_wire.sym} 4950 940 0 0 {name=l185 lab=BLB20}
N 4850 1460 4850 1560 {lab=Y}
N 4950 1460 4950 1600 {lab=YB}
C {sram512_column.sym} 5100 1300 0 0 {name=xcol21}
N 5050 720 5050 1140 {lab=BL21}
C {devices/lab_wire.sym} 5050 940 0 0 {name=l190 lab=BL21}
N 5150 720 5150 1140 {lab=BLB21}
C {devices/lab_wire.sym} 5150 940 0 0 {name=l192 lab=BLB21}
N 5050 1460 5050 1560 {lab=Y}
N 5150 1460 5150 1600 {lab=YB}
C {sram512_column.sym} 5300 1300 0 0 {name=xcol22}
N 5250 720 5250 1140 {lab=BL22}
C {devices/lab_wire.sym} 5250 940 0 0 {name=l197 lab=BL22}
N 5350 720 5350 1140 {lab=BLB22}
C {devices/lab_wire.sym} 5350 940 0 0 {name=l199 lab=BLB22}
N 5250 1460 5250 1560 {lab=Y}
N 5350 1460 5350 1600 {lab=YB}
C {sram512_column.sym} 5500 1300 0 0 {name=xcol23}
N 5450 720 5450 1140 {lab=BL23}
C {devices/lab_wire.sym} 5450 940 0 0 {name=l204 lab=BL23}
N 5550 720 5550 1140 {lab=BLB23}
C {devices/lab_wire.sym} 5550 940 0 0 {name=l206 lab=BLB23}
N 5450 1460 5450 1560 {lab=Y}
N 5550 1460 5550 1600 {lab=YB}
C {sram512_column.sym} 5700 1300 0 0 {name=xcol24}
N 5650 720 5650 1140 {lab=BL24}
C {devices/lab_wire.sym} 5650 940 0 0 {name=l211 lab=BL24}
N 5750 720 5750 1140 {lab=BLB24}
C {devices/lab_wire.sym} 5750 940 0 0 {name=l213 lab=BLB24}
N 5650 1460 5650 1560 {lab=Y}
N 5750 1460 5750 1600 {lab=YB}
C {sram512_column.sym} 5900 1300 0 0 {name=xcol25}
N 5850 720 5850 1140 {lab=BL25}
C {devices/lab_wire.sym} 5850 940 0 0 {name=l218 lab=BL25}
N 5950 720 5950 1140 {lab=BLB25}
C {devices/lab_wire.sym} 5950 940 0 0 {name=l220 lab=BLB25}
N 5850 1460 5850 1560 {lab=Y}
N 5950 1460 5950 1600 {lab=YB}
C {sram512_column.sym} 6100 1300 0 0 {name=xcol26}
N 6050 720 6050 1140 {lab=BL26}
C {devices/lab_wire.sym} 6050 940 0 0 {name=l225 lab=BL26}
N 6150 720 6150 1140 {lab=BLB26}
C {devices/lab_wire.sym} 6150 940 0 0 {name=l227 lab=BLB26}
N 6050 1460 6050 1560 {lab=Y}
N 6150 1460 6150 1600 {lab=YB}
C {sram512_column.sym} 6300 1300 0 0 {name=xcol27}
N 6250 720 6250 1140 {lab=BL27}
C {devices/lab_wire.sym} 6250 940 0 0 {name=l232 lab=BL27}
N 6350 720 6350 1140 {lab=BLB27}
C {devices/lab_wire.sym} 6350 940 0 0 {name=l234 lab=BLB27}
N 6250 1460 6250 1560 {lab=Y}
N 6350 1460 6350 1600 {lab=YB}
C {sram512_column.sym} 6500 1300 0 0 {name=xcol28}
N 6450 720 6450 1140 {lab=BL28}
C {devices/lab_wire.sym} 6450 940 0 0 {name=l239 lab=BL28}
N 6550 720 6550 1140 {lab=BLB28}
C {devices/lab_wire.sym} 6550 940 0 0 {name=l241 lab=BLB28}
N 6450 1460 6450 1560 {lab=Y}
N 6550 1460 6550 1600 {lab=YB}
C {sram512_column.sym} 6700 1300 0 0 {name=xcol29}
N 6650 720 6650 1140 {lab=BL29}
C {devices/lab_wire.sym} 6650 940 0 0 {name=l246 lab=BL29}
N 6750 720 6750 1140 {lab=BLB29}
C {devices/lab_wire.sym} 6750 940 0 0 {name=l248 lab=BLB29}
N 6650 1460 6650 1560 {lab=Y}
N 6750 1460 6750 1600 {lab=YB}
C {sram512_column.sym} 6900 1300 0 0 {name=xcol30}
N 6850 720 6850 1140 {lab=BL30}
C {devices/lab_wire.sym} 6850 940 0 0 {name=l253 lab=BL30}
N 6950 720 6950 1140 {lab=BLB30}
C {devices/lab_wire.sym} 6950 940 0 0 {name=l255 lab=BLB30}
N 6850 1460 6850 1560 {lab=Y}
N 6950 1460 6950 1600 {lab=YB}
C {sram512_column.sym} 7100 1300 0 0 {name=xcol31}
N 7050 720 7050 1140 {lab=BL31}
C {devices/lab_wire.sym} 7050 940 0 0 {name=l260 lab=BL31}
N 7150 720 7150 1140 {lab=BLB31}
C {devices/lab_wire.sym} 7150 940 0 0 {name=l262 lab=BLB31}
N 7050 1460 7050 1560 {lab=Y}
N 7150 1460 7150 1600 {lab=YB}
N 800 1560 7300 1560 {lab=Y}
C {devices/lab_wire.sym} 800 1560 0 0 {name=l266 lab=Y}
N 800 1600 7300 1600 {lab=YB}
C {devices/lab_wire.sym} 800 1600 0 0 {name=l268 lab=YB}
C {sram512_col_decoder.sym} 4000 2140 0 0 {name=xcol_decode}
N 900 1960 900 1460 {lab=COL0}
C {devices/lab_wire.sym} 900 1850 0 0 {name=l271 lab=COL0}
N 1100 1960 1100 1460 {lab=COL1}
C {devices/lab_wire.sym} 1100 1850 0 0 {name=l273 lab=COL1}
N 1300 1960 1300 1460 {lab=COL2}
C {devices/lab_wire.sym} 1300 1850 0 0 {name=l275 lab=COL2}
N 1500 1960 1500 1460 {lab=COL3}
C {devices/lab_wire.sym} 1500 1850 0 0 {name=l277 lab=COL3}
N 1700 1960 1700 1460 {lab=COL4}
C {devices/lab_wire.sym} 1700 1850 0 0 {name=l279 lab=COL4}
N 1900 1960 1900 1460 {lab=COL5}
C {devices/lab_wire.sym} 1900 1850 0 0 {name=l281 lab=COL5}
N 2100 1960 2100 1460 {lab=COL6}
C {devices/lab_wire.sym} 2100 1850 0 0 {name=l283 lab=COL6}
N 2300 1960 2300 1460 {lab=COL7}
C {devices/lab_wire.sym} 2300 1850 0 0 {name=l285 lab=COL7}
N 2500 1960 2500 1460 {lab=COL8}
C {devices/lab_wire.sym} 2500 1850 0 0 {name=l287 lab=COL8}
N 2700 1960 2700 1460 {lab=COL9}
C {devices/lab_wire.sym} 2700 1850 0 0 {name=l289 lab=COL9}
N 2900 1960 2900 1460 {lab=COL10}
C {devices/lab_wire.sym} 2900 1850 0 0 {name=l291 lab=COL10}
N 3100 1960 3100 1460 {lab=COL11}
C {devices/lab_wire.sym} 3100 1850 0 0 {name=l293 lab=COL11}
N 3300 1960 3300 1460 {lab=COL12}
C {devices/lab_wire.sym} 3300 1850 0 0 {name=l295 lab=COL12}
N 3500 1960 3500 1460 {lab=COL13}
C {devices/lab_wire.sym} 3500 1850 0 0 {name=l297 lab=COL13}
N 3700 1960 3700 1460 {lab=COL14}
C {devices/lab_wire.sym} 3700 1850 0 0 {name=l299 lab=COL14}
N 3900 1960 3900 1460 {lab=COL15}
C {devices/lab_wire.sym} 3900 1850 0 0 {name=l301 lab=COL15}
N 4100 1960 4100 1460 {lab=COL16}
C {devices/lab_wire.sym} 4100 1850 0 0 {name=l303 lab=COL16}
N 4300 1960 4300 1460 {lab=COL17}
C {devices/lab_wire.sym} 4300 1850 0 0 {name=l305 lab=COL17}
N 4500 1960 4500 1460 {lab=COL18}
C {devices/lab_wire.sym} 4500 1850 0 0 {name=l307 lab=COL18}
N 4700 1960 4700 1460 {lab=COL19}
C {devices/lab_wire.sym} 4700 1850 0 0 {name=l309 lab=COL19}
N 4900 1960 4900 1460 {lab=COL20}
C {devices/lab_wire.sym} 4900 1850 0 0 {name=l311 lab=COL20}
N 5100 1960 5100 1460 {lab=COL21}
C {devices/lab_wire.sym} 5100 1850 0 0 {name=l313 lab=COL21}
N 5300 1960 5300 1460 {lab=COL22}
C {devices/lab_wire.sym} 5300 1850 0 0 {name=l315 lab=COL22}
N 5500 1960 5500 1460 {lab=COL23}
C {devices/lab_wire.sym} 5500 1850 0 0 {name=l317 lab=COL23}
N 5700 1960 5700 1460 {lab=COL24}
C {devices/lab_wire.sym} 5700 1850 0 0 {name=l319 lab=COL24}
N 5900 1960 5900 1460 {lab=COL25}
C {devices/lab_wire.sym} 5900 1850 0 0 {name=l321 lab=COL25}
N 6100 1960 6100 1460 {lab=COL26}
C {devices/lab_wire.sym} 6100 1850 0 0 {name=l323 lab=COL26}
N 6300 1960 6300 1460 {lab=COL27}
C {devices/lab_wire.sym} 6300 1850 0 0 {name=l325 lab=COL27}
N 6500 1960 6500 1460 {lab=COL28}
C {devices/lab_wire.sym} 6500 1850 0 0 {name=l327 lab=COL28}
N 6700 1960 6700 1460 {lab=COL29}
C {devices/lab_wire.sym} 6700 1850 0 0 {name=l329 lab=COL29}
N 6900 1960 6900 1460 {lab=COL30}
C {devices/lab_wire.sym} 6900 1850 0 0 {name=l331 lab=COL30}
N 7100 1960 7100 1460 {lab=COL31}
C {devices/lab_wire.sym} 7100 1850 0 0 {name=l333 lab=COL31}
C {sense_amp_7t.sym} 5600 2730 0 0 {name=xsense}
N 5450 2670 5360 2670 {lab=Y}
N 5360 2670 5360 1560 {lab=Y}
N 5450 2730 5280 2730 {lab=YB}
N 5280 2730 5280 1600 {lab=YB}
C {TR-1umLIB/MP.sym} 2400 2500 0 0 {name=xpc_Y model=PMOS w=10.2u l=1u m=1 spiceprefix=X}
C {TR-1umLIB/MN.sym} 2400 2940 0 0 {name=xwrite_Y model=NMOS w=10.2u l=1u m=1 spiceprefix=X}
N 2440 2530 2560 2530 {lab=Y}
N 2560 2530 2560 1560 {lab=Y}
N 2440 2910 2620 2910 {lab=Y}
N 2620 2910 2620 1560 {lab=Y}
C {TR-1um_5_stdcell/AND2_X1.sym} 1950 2940 0 0 {name=xwrite_data0}
N 2060 2940 2400 2940 {lab=PD_Y}
C {devices/lab_wire.sym} 2200 2940 0 0 {name=l347 lab=PD_Y}
C {TR-1umLIB/MP.sym} 3700 2500 0 0 {name=xpc_YB model=PMOS w=10.2u l=1u m=1 spiceprefix=X}
C {TR-1umLIB/MN.sym} 3700 2940 0 0 {name=xwrite_YB model=NMOS w=10.2u l=1u m=1 spiceprefix=X}
N 3740 2530 3860 2530 {lab=YB}
N 3860 2530 3860 1600 {lab=YB}
N 3740 2910 3920 2910 {lab=YB}
N 3920 2910 3920 1600 {lab=YB}
C {TR-1um_5_stdcell/AND2_X1.sym} 3250 2940 0 0 {name=xwrite_data1}
N 3360 2940 3700 2940 {lab=PD_YB}
C {devices/lab_wire.sym} 3500 2940 0 0 {name=l356 lab=PD_YB}
C {sram512_controller.sym} 0 2040 0 0 {name=xctrl}
T {INPUT GATE ANTENNA CLAMPS | pad / ESD network connects at chip integration} -1100 760 0 0 0.28 0.28 {}
C {sram512_input_clamp.sym} -1100 980 0 0 {name=xinput_clk}
C {sram512_input_clamp.sym} -680 980 0 0 {name=xinput_reset}
C {sram512_input_clamp.sym} -260 980 0 0 {name=xinput_sdi}
C {sram512_input_clamp.sym} 160 980 0 0 {name=xinput_we}
T {Common lines Y / YB feed the shared write pulldown and 7T sense amplifier} 1000 3270 0 0 0.34 0.34 {}
T {E0 precharge; E1 release; E2 write drive; E3 WL; E4 SAE; E5 WL off; E6 capture; E7 end} 1000 3340 0 0 0.3 0.3 {}
C {devices/vsource.sym} -1100 3900 0 0 {name=VVDD value="'VSUP'"}
C {devices/lab_pin.sym} -1100 3870 0 0 {name=l366 lab=VDD}
C {devices/lab_pin.sym} -1100 3930 0 0 {name=l367 lab=0}
T {VDD stimulus} -1200 3720 0 0 0.3 0.3 {}
C {devices/vsource.sym} -500 3900 0 0 {name=VCLK value="PWL(0.000000000000e+00 'VSUP*0' 2.000000000000e-06 'VSUP*0' 2.005000000000e-06 'VSUP*1' 2.500000000000e-06 'VSUP*1' 2.505000000000e-06 'VSUP*0' 3.000000000000e-06 'VSUP*0' 3.005000000000e-06 'VSUP*1' 3.500000000000e-06 'VSUP*1' 3.505000000000e-06 'VSUP*0' 4.000000000000e-06 'VSUP*0' 4.005000000000e-06 'VSUP*1' 4.500000000000e-06 'VSUP*1' 4.505000000000e-06 'VSUP*0' 5.000000000000e-06 'VSUP*0' 5.005000000000e-06 'VSUP*1' 5.500000000000e-06 'VSUP*1' 5.505000000000e-06 'VSUP*0' 6.000000000000e-06 'VSUP*0' 6.005000000000e-06 'VSUP*1' 6.500000000000e-06 'VSUP*1' 6.505000000000e-06 'VSUP*0' 7.000000000000e-06 'VSUP*0' 7.005000000000e-06 'VSUP*1' 7.500000000000e-06 'VSUP*1' 7.505000000000e-06 'VSUP*0' 8.000000000000e-06 'VSUP*0' 8.005000000000e-06 'VSUP*1' 8.500000000000e-06 'VSUP*1' 8.505000000000e-06 'VSUP*0' 9.000000000000e-06 'VSUP*0' 9.005000000000e-06 'VSUP*1' 9.500000000000e-06 'VSUP*1' 9.505000000000e-06 'VSUP*0' 1.000000000000e-05 'VSUP*0' 1.000500000000e-05 'VSUP*1' 1.050000000000e-05 'VSUP*1' 1.050500000000e-05 'VSUP*0' 1.100000000000e-05 'VSUP*0' 1.100500000000e-05 'VSUP*1' 1.150000000000e-05 'VSUP*1' 1.150500000000e-05 'VSUP*0' 1.200000000000e-05 'VSUP*0' 1.200500000000e-05 'VSUP*1' 1.250000000000e-05 'VSUP*1' 1.250500000000e-05 'VSUP*0' 1.300000000000e-05 'VSUP*0' 1.300500000000e-05 'VSUP*1' 1.350000000000e-05 'VSUP*1' 1.350500000000e-05 'VSUP*0' 1.400000000000e-05 'VSUP*0' 1.400500000000e-05 'VSUP*1' 1.450000000000e-05 'VSUP*1' 1.450500000000e-05 'VSUP*0' 1.500000000000e-05 'VSUP*0' 1.500500000000e-05 'VSUP*1' 1.550000000000e-05 'VSUP*1' 1.550500000000e-05 'VSUP*0' 1.600000000000e-05 'VSUP*0' 1.600500000000e-05 'VSUP*1' 1.650000000000e-05 'VSUP*1' 1.650500000000e-05 'VSUP*0' 1.700000000000e-05 'VSUP*0' 1.700500000000e-05 'VSUP*1' 1.750000000000e-05 'VSUP*1' 1.750500000000e-05 'VSUP*0' 1.800000000000e-05 'VSUP*0' 1.800500000000e-05 'VSUP*1' 1.850000000000e-05 'VSUP*1' 1.850500000000e-05 'VSUP*0' 1.900000000000e-05 'VSUP*0' 1.900500000000e-05 'VSUP*1' 1.950000000000e-05 'VSUP*1' 1.950500000000e-05 'VSUP*0' 2.000000000000e-05 'VSUP*0' 2.000500000000e-05 'VSUP*1' 2.050000000000e-05 'VSUP*1' 2.050500000000e-05 'VSUP*0' 2.100000000000e-05 'VSUP*0' 2.100500000000e-05 'VSUP*1' 2.150000000000e-05 'VSUP*1' 2.150500000000e-05 'VSUP*0' 2.200000000000e-05 'VSUP*0' 2.200500000000e-05 'VSUP*1' 2.250000000000e-05 'VSUP*1' 2.250500000000e-05 'VSUP*0' 2.300000000000e-05 'VSUP*0' 2.300500000000e-05 'VSUP*1' 2.350000000000e-05 'VSUP*1' 2.350500000000e-05 'VSUP*0' 2.400000000000e-05 'VSUP*0' 2.400500000000e-05 'VSUP*1' 2.450000000000e-05 'VSUP*1' 2.450500000000e-05 'VSUP*0' 2.500000000000e-05 'VSUP*0' 2.500500000000e-05 'VSUP*1' 2.550000000000e-05 'VSUP*1' 2.550500000000e-05 'VSUP*0' 2.600000000000e-05 'VSUP*0' 2.600500000000e-05 'VSUP*1' 2.650000000000e-05 'VSUP*1' 2.650500000000e-05 'VSUP*0' 2.700000000000e-05 'VSUP*0' 2.700500000000e-05 'VSUP*1' 2.750000000000e-05 'VSUP*1' 2.750500000000e-05 'VSUP*0' 2.800000000000e-05 'VSUP*0' 2.800500000000e-05 'VSUP*1' 2.850000000000e-05 'VSUP*1' 2.850500000000e-05 'VSUP*0' 2.900000000000e-05 'VSUP*0' 2.900500000000e-05 'VSUP*1' 2.950000000000e-05 'VSUP*1' 2.950500000000e-05 'VSUP*0' 3.000000000000e-05 'VSUP*0' 3.000500000000e-05 'VSUP*1' 3.050000000000e-05 'VSUP*1' 3.050500000000e-05 'VSUP*0' 3.100000000000e-05 'VSUP*0' 3.100500000000e-05 'VSUP*1' 3.150000000000e-05 'VSUP*1' 3.150500000000e-05 'VSUP*0' 3.200000000000e-05 'VSUP*0' 3.200500000000e-05 'VSUP*1' 3.250000000000e-05 'VSUP*1' 3.250500000000e-05 'VSUP*0' 3.300000000000e-05 'VSUP*0' 3.300500000000e-05 'VSUP*1' 3.350000000000e-05 'VSUP*1' 3.350500000000e-05 'VSUP*0' 3.400000000000e-05 'VSUP*0' 3.400500000000e-05 'VSUP*1' 3.450000000000e-05 'VSUP*1' 3.450500000000e-05 'VSUP*0' 3.500000000000e-05 'VSUP*0' 3.500500000000e-05 'VSUP*1' 3.550000000000e-05 'VSUP*1' 3.550500000000e-05 'VSUP*0' 3.600000000000e-05 'VSUP*0' 3.600500000000e-05 'VSUP*1' 3.650000000000e-05 'VSUP*1' 3.650500000000e-05 'VSUP*0' 3.700000000000e-05 'VSUP*0' 3.700500000000e-05 'VSUP*1' 3.750000000000e-05 'VSUP*1' 3.750500000000e-05 'VSUP*0' 3.800000000000e-05 'VSUP*0' 3.800500000000e-05 'VSUP*1' 3.850000000000e-05 'VSUP*1' 3.850500000000e-05 'VSUP*0' 3.900000000000e-05 'VSUP*0' 3.900500000000e-05 'VSUP*1' 3.950000000000e-05 'VSUP*1' 3.950500000000e-05 'VSUP*0' 4.000000000000e-05 'VSUP*0' 4.000500000000e-05 'VSUP*1' 4.050000000000e-05 'VSUP*1' 4.050500000000e-05 'VSUP*0' 4.100000000000e-05 'VSUP*0' 4.100500000000e-05 'VSUP*1' 4.150000000000e-05 'VSUP*1' 4.150500000000e-05 'VSUP*0' 4.200000000000e-05 'VSUP*0' 4.200500000000e-05 'VSUP*1' 4.250000000000e-05 'VSUP*1' 4.250500000000e-05 'VSUP*0' 4.300000000000e-05 'VSUP*0' 4.300500000000e-05 'VSUP*1' 4.350000000000e-05 'VSUP*1' 4.350500000000e-05 'VSUP*0' 4.400000000000e-05 'VSUP*0' 4.400500000000e-05 'VSUP*1' 4.450000000000e-05 'VSUP*1' 4.450500000000e-05 'VSUP*0' 4.500000000000e-05 'VSUP*0' 4.500500000000e-05 'VSUP*1' 4.550000000000e-05 'VSUP*1' 4.550500000000e-05 'VSUP*0' 4.600000000000e-05 'VSUP*0' 4.600500000000e-05 'VSUP*1' 4.650000000000e-05 'VSUP*1' 4.650500000000e-05 'VSUP*0' 4.700000000000e-05 'VSUP*0' 4.700500000000e-05 'VSUP*1' 4.750000000000e-05 'VSUP*1' 4.750500000000e-05 'VSUP*0' 4.800000000000e-05 'VSUP*0' 4.800500000000e-05 'VSUP*1' 4.850000000000e-05 'VSUP*1' 4.850500000000e-05 'VSUP*0' 4.900000000000e-05 'VSUP*0' 4.900500000000e-05 'VSUP*1' 4.950000000000e-05 'VSUP*1' 4.950500000000e-05 'VSUP*0' 5.000000000000e-05 'VSUP*0' 5.000500000000e-05 'VSUP*1' 5.050000000000e-05 'VSUP*1' 5.050500000000e-05 'VSUP*0' 5.100000000000e-05 'VSUP*0' 5.100500000000e-05 'VSUP*1' 5.150000000000e-05 'VSUP*1' 5.150500000000e-05 'VSUP*0' 5.200000000000e-05 'VSUP*0' 5.200500000000e-05 'VSUP*1' 5.250000000000e-05 'VSUP*1' 5.250500000000e-05 'VSUP*0' 5.300000000000e-05 'VSUP*0' 5.300500000000e-05 'VSUP*1' 5.350000000000e-05 'VSUP*1' 5.350500000000e-05 'VSUP*0' 5.400000000000e-05 'VSUP*0' 5.400500000000e-05 'VSUP*1' 5.450000000000e-05 'VSUP*1' 5.450500000000e-05 'VSUP*0' 5.500000000000e-05 'VSUP*0' 5.500500000000e-05 'VSUP*1' 5.550000000000e-05 'VSUP*1' 5.550500000000e-05 'VSUP*0' 5.600000000000e-05 'VSUP*0' 5.600500000000e-05 'VSUP*1' 5.650000000000e-05 'VSUP*1' 5.650500000000e-05 'VSUP*0' 5.700000000000e-05 'VSUP*0' 5.700500000000e-05 'VSUP*1' 5.750000000000e-05 'VSUP*1' 5.750500000000e-05 'VSUP*0' 5.800000000000e-05 'VSUP*0' 5.800500000000e-05 'VSUP*1' 5.850000000000e-05 'VSUP*1' 5.850500000000e-05 'VSUP*0' 5.900000000000e-05 'VSUP*0' 5.900500000000e-05 'VSUP*1' 5.950000000000e-05 'VSUP*1' 5.950500000000e-05 'VSUP*0' 6.000000000000e-05 'VSUP*0' 6.000500000000e-05 'VSUP*1' 6.050000000000e-05 'VSUP*1' 6.050500000000e-05 'VSUP*0' 6.100000000000e-05 'VSUP*0' 6.100500000000e-05 'VSUP*1' 6.150000000000e-05 'VSUP*1' 6.150500000000e-05 'VSUP*0' 6.200000000000e-05 'VSUP*0' 6.200500000000e-05 'VSUP*1' 6.250000000000e-05 'VSUP*1' 6.250500000000e-05 'VSUP*0' 6.300000000000e-05 'VSUP*0' 6.300500000000e-05 'VSUP*1' 6.350000000000e-05 'VSUP*1' 6.350500000000e-05 'VSUP*0' 6.400000000000e-05 'VSUP*0' 6.400500000000e-05 'VSUP*1' 6.450000000000e-05 'VSUP*1' 6.450500000000e-05 'VSUP*0' 6.500000000000e-05 'VSUP*0' 6.500500000000e-05 'VSUP*1' 6.550000000000e-05 'VSUP*1' 6.550500000000e-05 'VSUP*0' 6.600000000000e-05 'VSUP*0' 6.600500000000e-05 'VSUP*1' 6.650000000000e-05 'VSUP*1' 6.650500000000e-05 'VSUP*0' 6.700000000000e-05 'VSUP*0' 6.700500000000e-05 'VSUP*1' 6.750000000000e-05 'VSUP*1' 6.750500000000e-05 'VSUP*0' 6.800000000000e-05 'VSUP*0' 6.800500000000e-05 'VSUP*1' 6.850000000000e-05 'VSUP*1' 6.850500000000e-05 'VSUP*0' 6.900000000000e-05 'VSUP*0' 6.900500000000e-05 'VSUP*1' 6.950000000000e-05 'VSUP*1' 6.950500000000e-05 'VSUP*0' 7.000000000000e-05 'VSUP*0' 7.000500000000e-05 'VSUP*1' 7.050000000000e-05 'VSUP*1' 7.050500000000e-05 'VSUP*0' 7.100000000000e-05 'VSUP*0' 7.100500000000e-05 'VSUP*1' 7.150000000000e-05 'VSUP*1' 7.150500000000e-05 'VSUP*0' 7.200000000000e-05 'VSUP*0' 7.200500000000e-05 'VSUP*1' 7.250000000000e-05 'VSUP*1' 7.250500000000e-05 'VSUP*0' 7.300000000000e-05 'VSUP*0' 7.300500000000e-05 'VSUP*1' 7.350000000000e-05 'VSUP*1' 7.350500000000e-05 'VSUP*0' 7.400000000000e-05 'VSUP*0' 7.400500000000e-05 'VSUP*1' 7.450000000000e-05 'VSUP*1' 7.450500000000e-05 'VSUP*0' 7.500000000000e-05 'VSUP*0' 7.500500000000e-05 'VSUP*1' 7.550000000000e-05 'VSUP*1' 7.550500000000e-05 'VSUP*0' 7.600000000000e-05 'VSUP*0' 7.600500000000e-05 'VSUP*1' 7.650000000000e-05 'VSUP*1' 7.650500000000e-05 'VSUP*0' 7.700000000000e-05 'VSUP*0' 7.700500000000e-05 'VSUP*1' 7.750000000000e-05 'VSUP*1' 7.750500000000e-05 'VSUP*0' 7.800000000000e-05 'VSUP*0' 7.800500000000e-05 'VSUP*1' 7.850000000000e-05 'VSUP*1' 7.850500000000e-05 'VSUP*0' 7.900000000000e-05 'VSUP*0' 7.900500000000e-05 'VSUP*1' 7.950000000000e-05 'VSUP*1' 7.950500000000e-05 'VSUP*0' 8.000000000000e-05 'VSUP*0' 8.000500000000e-05 'VSUP*1' 8.050000000000e-05 'VSUP*1' 8.050500000000e-05 'VSUP*0' 8.100000000000e-05 'VSUP*0' 8.100500000000e-05 'VSUP*1' 8.150000000000e-05 'VSUP*1' 8.150500000000e-05 'VSUP*0' 8.200000000000e-05 'VSUP*0' 8.200500000000e-05 'VSUP*1' 8.250000000000e-05 'VSUP*1' 8.250500000000e-05 'VSUP*0' 8.300000000000e-05 'VSUP*0' 8.300500000000e-05 'VSUP*1' 8.350000000000e-05 'VSUP*1' 8.350500000000e-05 'VSUP*0' 8.400000000000e-05 'VSUP*0' 8.400500000000e-05 'VSUP*1' 8.450000000000e-05 'VSUP*1' 8.450500000000e-05 'VSUP*0' 8.500000000000e-05 'VSUP*0' 8.500500000000e-05 'VSUP*1' 8.550000000000e-05 'VSUP*1' 8.550500000000e-05 'VSUP*0' 8.600000000000e-05 'VSUP*0' 8.600500000000e-05 'VSUP*1' 8.650000000000e-05 'VSUP*1' 8.650500000000e-05 'VSUP*0' 8.700000000000e-05 'VSUP*0' 8.700500000000e-05 'VSUP*1' 8.750000000000e-05 'VSUP*1' 8.750500000000e-05 'VSUP*0' 8.800000000000e-05 'VSUP*0' 8.800500000000e-05 'VSUP*1' 8.850000000000e-05 'VSUP*1' 8.850500000000e-05 'VSUP*0' 8.900000000000e-05 'VSUP*0' 8.900500000000e-05 'VSUP*1' 8.950000000000e-05 'VSUP*1' 8.950500000000e-05 'VSUP*0' 9.000000000000e-05 'VSUP*0' 9.000500000000e-05 'VSUP*1' 9.050000000000e-05 'VSUP*1' 9.050500000000e-05 'VSUP*0' 9.100000000000e-05 'VSUP*0' 9.100500000000e-05 'VSUP*1' 9.150000000000e-05 'VSUP*1' 9.150500000000e-05 'VSUP*0' 9.200000000000e-05 'VSUP*0' 9.200500000000e-05 'VSUP*1' 9.250000000000e-05 'VSUP*1' 9.250500000000e-05 'VSUP*0' 9.300000000000e-05 'VSUP*0' 9.300500000000e-05 'VSUP*1' 9.350000000000e-05 'VSUP*1' 9.350500000000e-05 'VSUP*0' 9.400000000000e-05 'VSUP*0' 9.400500000000e-05 'VSUP*1' 9.450000000000e-05 'VSUP*1' 9.450500000000e-05 'VSUP*0' 9.500000000000e-05 'VSUP*0' 9.500500000000e-05 'VSUP*1' 9.550000000000e-05 'VSUP*1' 9.550500000000e-05 'VSUP*0' 9.600000000000e-05 'VSUP*0' 9.600500000000e-05 'VSUP*1' 9.650000000000e-05 'VSUP*1' 9.650500000000e-05 'VSUP*0' 9.700000000000e-05 'VSUP*0' 9.700500000000e-05 'VSUP*1' 9.750000000000e-05 'VSUP*1' 9.750500000000e-05 'VSUP*0' 9.800000000000e-05 'VSUP*0' 9.800500000000e-05 'VSUP*1' 9.850000000000e-05 'VSUP*1' 9.850500000000e-05 'VSUP*0' 9.900000000000e-05 'VSUP*0' 9.900500000000e-05 'VSUP*1' 9.950000000000e-05 'VSUP*1' 9.950500000000e-05 'VSUP*0' 1.000000000000e-04 'VSUP*0' 1.000050000000e-04 'VSUP*1' 1.005000000000e-04 'VSUP*1' 1.005050000000e-04 'VSUP*0' 1.010000000000e-04 'VSUP*0' 1.010050000000e-04 'VSUP*1' 1.015000000000e-04 'VSUP*1' 1.015050000000e-04 'VSUP*0' 1.020000000000e-04 'VSUP*0' 1.020050000000e-04 'VSUP*1' 1.025000000000e-04 'VSUP*1' 1.025050000000e-04 'VSUP*0' 1.030000000000e-04 'VSUP*0' 1.030050000000e-04 'VSUP*1' 1.035000000000e-04 'VSUP*1' 1.035050000000e-04 'VSUP*0' 1.040000000000e-04 'VSUP*0' 1.040050000000e-04 'VSUP*1' 1.045000000000e-04 'VSUP*1' 1.045050000000e-04 'VSUP*0' 1.050000000000e-04 'VSUP*0' 1.050050000000e-04 'VSUP*1' 1.055000000000e-04 'VSUP*1' 1.055050000000e-04 'VSUP*0' 1.060000000000e-04 'VSUP*0' 1.060050000000e-04 'VSUP*1' 1.065000000000e-04 'VSUP*1' 1.065050000000e-04 'VSUP*0' 1.070000000000e-04 'VSUP*0' 1.070050000000e-04 'VSUP*1' 1.075000000000e-04 'VSUP*1' 1.075050000000e-04 'VSUP*0' 1.080000000000e-04 'VSUP*0' 1.080050000000e-04 'VSUP*1' 1.085000000000e-04 'VSUP*1' 1.085050000000e-04 'VSUP*0' 1.090000000000e-04 'VSUP*0' 1.090050000000e-04 'VSUP*1' 1.095000000000e-04 'VSUP*1' 1.095050000000e-04 'VSUP*0' 1.100000000000e-04 'VSUP*0' 1.100050000000e-04 'VSUP*1' 1.105000000000e-04 'VSUP*1' 1.105050000000e-04 'VSUP*0' 1.110000000000e-04 'VSUP*0' 1.110050000000e-04 'VSUP*1' 1.115000000000e-04 'VSUP*1' 1.115050000000e-04 'VSUP*0' 1.120000000000e-04 'VSUP*0' 1.120050000000e-04 'VSUP*1' 1.125000000000e-04 'VSUP*1' 1.125050000000e-04 'VSUP*0' 1.130000000000e-04 'VSUP*0' 1.130050000000e-04 'VSUP*1' 1.135000000000e-04 'VSUP*1' 1.135050000000e-04 'VSUP*0' 1.140000000000e-04 'VSUP*0' 1.140050000000e-04 'VSUP*1' 1.145000000000e-04 'VSUP*1' 1.145050000000e-04 'VSUP*0' 1.150000000000e-04 'VSUP*0' 1.150050000000e-04 'VSUP*1' 1.155000000000e-04 'VSUP*1' 1.155050000000e-04 'VSUP*0' 1.160000000000e-04 'VSUP*0' 1.160050000000e-04 'VSUP*1' 1.165000000000e-04 'VSUP*1' 1.165050000000e-04 'VSUP*0' 1.170000000000e-04 'VSUP*0' 1.170050000000e-04 'VSUP*1' 1.175000000000e-04 'VSUP*1' 1.175050000000e-04 'VSUP*0' 1.180000000000e-04 'VSUP*0' 1.180050000000e-04 'VSUP*1' 1.185000000000e-04 'VSUP*1' 1.185050000000e-04 'VSUP*0' 1.190000000000e-04 'VSUP*0' 1.190050000000e-04 'VSUP*1' 1.195000000000e-04 'VSUP*1' 1.195050000000e-04 'VSUP*0' 1.200000000000e-04 'VSUP*0' 1.200050000000e-04 'VSUP*1' 1.205000000000e-04 'VSUP*1' 1.205050000000e-04 'VSUP*0' 1.210000000000e-04 'VSUP*0' 1.210050000000e-04 'VSUP*1' 1.215000000000e-04 'VSUP*1' 1.215050000000e-04 'VSUP*0' 1.220000000000e-04 'VSUP*0' 1.220050000000e-04 'VSUP*1' 1.225000000000e-04 'VSUP*1' 1.225050000000e-04 'VSUP*0' 1.230000000000e-04 'VSUP*0' 1.230050000000e-04 'VSUP*1' 1.235000000000e-04 'VSUP*1' 1.235050000000e-04 'VSUP*0' 1.240000000000e-04 'VSUP*0' 1.240050000000e-04 'VSUP*1' 1.245000000000e-04 'VSUP*1' 1.245050000000e-04 'VSUP*0' 1.250000000000e-04 'VSUP*0' 1.250050000000e-04 'VSUP*1' 1.255000000000e-04 'VSUP*1' 1.255050000000e-04 'VSUP*0' 1.260000000000e-04 'VSUP*0' 1.260050000000e-04 'VSUP*1' 1.265000000000e-04 'VSUP*1' 1.265050000000e-04 'VSUP*0' 1.270000000000e-04 'VSUP*0' 1.270050000000e-04 'VSUP*1' 1.275000000000e-04 'VSUP*1' 1.275050000000e-04 'VSUP*0' 1.280000000000e-04 'VSUP*0' 1.280050000000e-04 'VSUP*1' 1.285000000000e-04 'VSUP*1' 1.285050000000e-04 'VSUP*0' 1.290000000000e-04 'VSUP*0' 1.290050000000e-04 'VSUP*1' 1.295000000000e-04 'VSUP*1' 1.295050000000e-04 'VSUP*0' 1.300000000000e-04 'VSUP*0' 1.300050000000e-04 'VSUP*1' 1.305000000000e-04 'VSUP*1' 1.305050000000e-04 'VSUP*0' 1.310000000000e-04 'VSUP*0' 1.310050000000e-04 'VSUP*1' 1.315000000000e-04 'VSUP*1' 1.315050000000e-04 'VSUP*0' 1.320000000000e-04 'VSUP*0' 1.320050000000e-04 'VSUP*1' 1.325000000000e-04 'VSUP*1' 1.325050000000e-04 'VSUP*0' 1.330000000000e-04 'VSUP*0' 1.330050000000e-04 'VSUP*1' 1.335000000000e-04 'VSUP*1' 1.335050000000e-04 'VSUP*0' 1.340000000000e-04 'VSUP*0' 1.340050000000e-04 'VSUP*1' 1.345000000000e-04 'VSUP*1' 1.345050000000e-04 'VSUP*0' 1.350000000000e-04 'VSUP*0' 1.350050000000e-04 'VSUP*1' 1.355000000000e-04 'VSUP*1' 1.355050000000e-04 'VSUP*0' 1.360000000000e-04 'VSUP*0' 1.360050000000e-04 'VSUP*1' 1.365000000000e-04 'VSUP*1' 1.365050000000e-04 'VSUP*0' 1.370000000000e-04 'VSUP*0' 1.370050000000e-04 'VSUP*1' 1.375000000000e-04 'VSUP*1' 1.375050000000e-04 'VSUP*0' 1.380000000000e-04 'VSUP*0' 1.380050000000e-04 'VSUP*1' 1.385000000000e-04 'VSUP*1' 1.385050000000e-04 'VSUP*0' 1.390000000000e-04 'VSUP*0' 1.390050000000e-04 'VSUP*1' 1.395000000000e-04 'VSUP*1' 1.395050000000e-04 'VSUP*0' 1.400000000000e-04 'VSUP*0' 1.400050000000e-04 'VSUP*1' 1.405000000000e-04 'VSUP*1' 1.405050000000e-04 'VSUP*0' 1.410000000000e-04 'VSUP*0' 1.410050000000e-04 'VSUP*1' 1.415000000000e-04 'VSUP*1' 1.415050000000e-04 'VSUP*0' 1.420000000000e-04 'VSUP*0' 1.420050000000e-04 'VSUP*1' 1.425000000000e-04 'VSUP*1' 1.425050000000e-04 'VSUP*0' 1.430000000000e-04 'VSUP*0' 1.430050000000e-04 'VSUP*1' 1.435000000000e-04 'VSUP*1' 1.435050000000e-04 'VSUP*0' 1.440000000000e-04 'VSUP*0' 1.440050000000e-04 'VSUP*1' 1.445000000000e-04 'VSUP*1' 1.445050000000e-04 'VSUP*0' 1.450000000000e-04 'VSUP*0' 1.450050000000e-04 'VSUP*1' 1.455000000000e-04 'VSUP*1' 1.455050000000e-04 'VSUP*0' 1.460000000000e-04 'VSUP*0' 1.460050000000e-04 'VSUP*1' 1.465000000000e-04 'VSUP*1' 1.465050000000e-04 'VSUP*0' 1.470000000000e-04 'VSUP*0' 1.470050000000e-04 'VSUP*1' 1.475000000000e-04 'VSUP*1' 1.475050000000e-04 'VSUP*0' 1.480000000000e-04 'VSUP*0' 1.480050000000e-04 'VSUP*1' 1.485000000000e-04 'VSUP*1' 1.485050000000e-04 'VSUP*0' 1.490000000000e-04 'VSUP*0' 1.490050000000e-04 'VSUP*1' 1.495000000000e-04 'VSUP*1' 1.495050000000e-04 'VSUP*0' 1.500000000000e-04 'VSUP*0' 1.500050000000e-04 'VSUP*1' 1.505000000000e-04 'VSUP*1' 1.505050000000e-04 'VSUP*0' 1.510000000000e-04 'VSUP*0' 1.510050000000e-04 'VSUP*1' 1.515000000000e-04 'VSUP*1' 1.515050000000e-04 'VSUP*0' 1.520000000000e-04 'VSUP*0' 1.520050000000e-04 'VSUP*1' 1.525000000000e-04 'VSUP*1' 1.525050000000e-04 'VSUP*0' 1.530000000000e-04 'VSUP*0' 1.530050000000e-04 'VSUP*1' 1.535000000000e-04 'VSUP*1' 1.535050000000e-04 'VSUP*0' 1.540000000000e-04 'VSUP*0' 1.540050000000e-04 'VSUP*1' 1.545000000000e-04 'VSUP*1' 1.545050000000e-04 'VSUP*0' 1.550000000000e-04 'VSUP*0' 1.550050000000e-04 'VSUP*1' 1.555000000000e-04 'VSUP*1' 1.555050000000e-04 'VSUP*0' 1.560000000000e-04 'VSUP*0' 1.560050000000e-04 'VSUP*1' 1.565000000000e-04 'VSUP*1' 1.565050000000e-04 'VSUP*0' 1.570000000000e-04 'VSUP*0' 1.570050000000e-04 'VSUP*1' 1.575000000000e-04 'VSUP*1' 1.575050000000e-04 'VSUP*0' 1.580000000000e-04 'VSUP*0' 1.580050000000e-04 'VSUP*1' 1.585000000000e-04 'VSUP*1' 1.585050000000e-04 'VSUP*0' 1.590000000000e-04 'VSUP*0' 1.590050000000e-04 'VSUP*1' 1.595000000000e-04 'VSUP*1' 1.595050000000e-04 'VSUP*0' 1.600000000000e-04 'VSUP*0' 1.600050000000e-04 'VSUP*1' 1.605000000000e-04 'VSUP*1' 1.605050000000e-04 'VSUP*0' 1.610000000000e-04 'VSUP*0' 1.610050000000e-04 'VSUP*1' 1.615000000000e-04 'VSUP*1' 1.615050000000e-04 'VSUP*0' 1.620000000000e-04 'VSUP*0' 1.620050000000e-04 'VSUP*1' 1.625000000000e-04 'VSUP*1' 1.625050000000e-04 'VSUP*0' 1.630000000000e-04 'VSUP*0' 1.630050000000e-04 'VSUP*1' 1.635000000000e-04 'VSUP*1' 1.635050000000e-04 'VSUP*0' 1.640000000000e-04 'VSUP*0' 1.640050000000e-04 'VSUP*1' 1.645000000000e-04 'VSUP*1' 1.645050000000e-04 'VSUP*0' 1.650000000000e-04 'VSUP*0' 1.650050000000e-04 'VSUP*1' 1.655000000000e-04 'VSUP*1' 1.655050000000e-04 'VSUP*0' 1.660000000000e-04 'VSUP*0' 1.660050000000e-04 'VSUP*1' 1.665000000000e-04 'VSUP*1' 1.665050000000e-04 'VSUP*0' 1.670000000000e-04 'VSUP*0' 1.670050000000e-04 'VSUP*1' 1.675000000000e-04 'VSUP*1' 1.675050000000e-04 'VSUP*0' 1.680000000000e-04 'VSUP*0' 1.680050000000e-04 'VSUP*1' 1.685000000000e-04 'VSUP*1' 1.685050000000e-04 'VSUP*0' 1.690000000000e-04 'VSUP*0' 1.690050000000e-04 'VSUP*1' 1.695000000000e-04 'VSUP*1' 1.695050000000e-04 'VSUP*0' 1.700000000000e-04 'VSUP*0' 1.700050000000e-04 'VSUP*1' 1.705000000000e-04 'VSUP*1' 1.705050000000e-04 'VSUP*0' 1.710000000000e-04 'VSUP*0' 1.710050000000e-04 'VSUP*1' 1.715000000000e-04 'VSUP*1' 1.715050000000e-04 'VSUP*0' 1.720000000000e-04 'VSUP*0' 1.720050000000e-04 'VSUP*1' 1.725000000000e-04 'VSUP*1' 1.725050000000e-04 'VSUP*0' 1.730000000000e-04 'VSUP*0' 1.730050000000e-04 'VSUP*1' 1.735000000000e-04 'VSUP*1' 1.735050000000e-04 'VSUP*0' 1.740000000000e-04 'VSUP*0' 1.740050000000e-04 'VSUP*1' 1.745000000000e-04 'VSUP*1' 1.745050000000e-04 'VSUP*0' 1.750000000000e-04 'VSUP*0' 1.750050000000e-04 'VSUP*1' 1.755000000000e-04 'VSUP*1' 1.755050000000e-04 'VSUP*0' 1.760000000000e-04 'VSUP*0' 1.760050000000e-04 'VSUP*1' 1.765000000000e-04 'VSUP*1' 1.765050000000e-04 'VSUP*0' 1.770000000000e-04 'VSUP*0' 1.770050000000e-04 'VSUP*1' 1.775000000000e-04 'VSUP*1' 1.775050000000e-04 'VSUP*0' 1.780000000000e-04 'VSUP*0' 1.780050000000e-04 'VSUP*1' 1.785000000000e-04 'VSUP*1' 1.785050000000e-04 'VSUP*0' 1.790000000000e-04 'VSUP*0' 1.790050000000e-04 'VSUP*1' 1.795000000000e-04 'VSUP*1' 1.795050000000e-04 'VSUP*0' 1.800000000000e-04 'VSUP*0' 1.800050000000e-04 'VSUP*1' 1.805000000000e-04 'VSUP*1' 1.805050000000e-04 'VSUP*0' 1.810000000000e-04 'VSUP*0' 1.810050000000e-04 'VSUP*1' 1.815000000000e-04 'VSUP*1' 1.815050000000e-04 'VSUP*0' 1.820000000000e-04 'VSUP*0' 1.820050000000e-04 'VSUP*1' 1.825000000000e-04 'VSUP*1' 1.825050000000e-04 'VSUP*0' 1.830000000000e-04 'VSUP*0' 1.830050000000e-04 'VSUP*1' 1.835000000000e-04 'VSUP*1' 1.835050000000e-04 'VSUP*0' 1.840000000000e-04 'VSUP*0' 1.840050000000e-04 'VSUP*1' 1.845000000000e-04 'VSUP*1' 1.845050000000e-04 'VSUP*0' 1.850000000000e-04 'VSUP*0' 1.850050000000e-04 'VSUP*1' 1.855000000000e-04 'VSUP*1' 1.855050000000e-04 'VSUP*0' 1.860000000000e-04 'VSUP*0' 1.860050000000e-04 'VSUP*1' 1.865000000000e-04 'VSUP*1' 1.865050000000e-04 'VSUP*0' 1.870000000000e-04 'VSUP*0' 1.870050000000e-04 'VSUP*1' 1.875000000000e-04 'VSUP*1' 1.875050000000e-04 'VSUP*0' 1.880000000000e-04 'VSUP*0' 1.880050000000e-04 'VSUP*1' 1.885000000000e-04 'VSUP*1' 1.885050000000e-04 'VSUP*0' 1.890000000000e-04 'VSUP*0' 1.890050000000e-04 'VSUP*1' 1.895000000000e-04 'VSUP*1' 1.895050000000e-04 'VSUP*0' 1.900000000000e-04 'VSUP*0' 1.900050000000e-04 'VSUP*1' 1.905000000000e-04 'VSUP*1' 1.905050000000e-04 'VSUP*0' 1.910000000000e-04 'VSUP*0' 1.910050000000e-04 'VSUP*1' 1.915000000000e-04 'VSUP*1' 1.915050000000e-04 'VSUP*0' 1.920000000000e-04 'VSUP*0' 1.920050000000e-04 'VSUP*1' 1.925000000000e-04 'VSUP*1' 1.925050000000e-04 'VSUP*0' 1.930000000000e-04 'VSUP*0' 1.930050000000e-04 'VSUP*1' 1.935000000000e-04 'VSUP*1' 1.935050000000e-04 'VSUP*0' 1.940000000000e-04 'VSUP*0' 1.940050000000e-04 'VSUP*1' 1.945000000000e-04 'VSUP*1' 1.945050000000e-04 'VSUP*0' 1.950000000000e-04 'VSUP*0' 1.950050000000e-04 'VSUP*1' 1.955000000000e-04 'VSUP*1' 1.955050000000e-04 'VSUP*0' 1.960000000000e-04 'VSUP*0' 1.960050000000e-04 'VSUP*1' 1.965000000000e-04 'VSUP*1' 1.965050000000e-04 'VSUP*0' 1.970000000000e-04 'VSUP*0' 1.970050000000e-04 'VSUP*1' 1.975000000000e-04 'VSUP*1' 1.975050000000e-04 'VSUP*0' 1.980000000000e-04 'VSUP*0' 1.980050000000e-04 'VSUP*1' 1.985000000000e-04 'VSUP*1' 1.985050000000e-04 'VSUP*0' 1.990000000000e-04 'VSUP*0' 1.990050000000e-04 'VSUP*1' 1.995000000000e-04 'VSUP*1' 1.995050000000e-04 'VSUP*0' 2.000000000000e-04 'VSUP*0' 2.000050000000e-04 'VSUP*1' 2.005000000000e-04 'VSUP*1' 2.005050000000e-04 'VSUP*0' 2.010000000000e-04 'VSUP*0' 2.010050000000e-04 'VSUP*1' 2.015000000000e-04 'VSUP*1' 2.015050000000e-04 'VSUP*0' 2.020000000000e-04 'VSUP*0' 2.020050000000e-04 'VSUP*1' 2.025000000000e-04 'VSUP*1' 2.025050000000e-04 'VSUP*0' 2.030000000000e-04 'VSUP*0' 2.030050000000e-04 'VSUP*1' 2.035000000000e-04 'VSUP*1' 2.035050000000e-04 'VSUP*0' 2.040000000000e-04 'VSUP*0' 2.040050000000e-04 'VSUP*1' 2.045000000000e-04 'VSUP*1' 2.045050000000e-04 'VSUP*0' 2.050000000000e-04 'VSUP*0' 2.050050000000e-04 'VSUP*1' 2.055000000000e-04 'VSUP*1' 2.055050000000e-04 'VSUP*0' 2.060000000000e-04 'VSUP*0' 2.060050000000e-04 'VSUP*1' 2.065000000000e-04 'VSUP*1' 2.065050000000e-04 'VSUP*0' 2.070000000000e-04 'VSUP*0' 2.070050000000e-04 'VSUP*1' 2.075000000000e-04 'VSUP*1' 2.075050000000e-04 'VSUP*0' 2.080000000000e-04 'VSUP*0' 2.080050000000e-04 'VSUP*1' 2.085000000000e-04 'VSUP*1' 2.085050000000e-04 'VSUP*0' 2.090000000000e-04 'VSUP*0' 2.090050000000e-04 'VSUP*1' 2.095000000000e-04 'VSUP*1' 2.095050000000e-04 'VSUP*0' 2.100000000000e-04 'VSUP*0' 2.100050000000e-04 'VSUP*1' 2.105000000000e-04 'VSUP*1' 2.105050000000e-04 'VSUP*0' 2.110000000000e-04 'VSUP*0' 2.110050000000e-04 'VSUP*1' 2.115000000000e-04 'VSUP*1' 2.115050000000e-04 'VSUP*0' 2.120000000000e-04 'VSUP*0' 2.120050000000e-04 'VSUP*1' 2.125000000000e-04 'VSUP*1' 2.125050000000e-04 'VSUP*0' 2.130000000000e-04 'VSUP*0' 2.130050000000e-04 'VSUP*1' 2.135000000000e-04 'VSUP*1' 2.135050000000e-04 'VSUP*0' 2.140000000000e-04 'VSUP*0' 2.140050000000e-04 'VSUP*1' 2.145000000000e-04 'VSUP*1' 2.145050000000e-04 'VSUP*0' 2.150000000000e-04 'VSUP*0' 2.150050000000e-04 'VSUP*1' 2.155000000000e-04 'VSUP*1' 2.155050000000e-04 'VSUP*0' 2.160000000000e-04 'VSUP*0' 2.160050000000e-04 'VSUP*1' 2.165000000000e-04 'VSUP*1' 2.165050000000e-04 'VSUP*0' 2.170000000000e-04 'VSUP*0' 2.170050000000e-04 'VSUP*1' 2.175000000000e-04 'VSUP*1' 2.175050000000e-04 'VSUP*0' 2.180000000000e-04 'VSUP*0' 2.180050000000e-04 'VSUP*1' 2.185000000000e-04 'VSUP*1' 2.185050000000e-04 'VSUP*0' 2.190000000000e-04 'VSUP*0' 2.190050000000e-04 'VSUP*1' 2.195000000000e-04 'VSUP*1' 2.195050000000e-04 'VSUP*0' 2.200000000000e-04 'VSUP*0' 2.200050000000e-04 'VSUP*1' 2.205000000000e-04 'VSUP*1' 2.205050000000e-04 'VSUP*0' 2.210000000000e-04 'VSUP*0' 2.210050000000e-04 'VSUP*1' 2.215000000000e-04 'VSUP*1' 2.215050000000e-04 'VSUP*0' 2.220000000000e-04 'VSUP*0' 2.220050000000e-04 'VSUP*1' 2.225000000000e-04 'VSUP*1' 2.225050000000e-04 'VSUP*0' 2.230000000000e-04 'VSUP*0' 2.230050000000e-04 'VSUP*1' 2.235000000000e-04 'VSUP*1' 2.235050000000e-04 'VSUP*0' 2.240000000000e-04 'VSUP*0' 2.240050000000e-04 'VSUP*1' 2.245000000000e-04 'VSUP*1' 2.245050000000e-04 'VSUP*0' 2.250000000000e-04 'VSUP*0' 2.250050000000e-04 'VSUP*1' 2.255000000000e-04 'VSUP*1' 2.255050000000e-04 'VSUP*0' 2.260000000000e-04 'VSUP*0' 2.260050000000e-04 'VSUP*1' 2.265000000000e-04 'VSUP*1' 2.265050000000e-04 'VSUP*0' 2.270000000000e-04 'VSUP*0' 2.270050000000e-04 'VSUP*1' 2.275000000000e-04 'VSUP*1' 2.275050000000e-04 'VSUP*0' 2.280000000000e-04 'VSUP*0' 2.280050000000e-04 'VSUP*1' 2.285000000000e-04 'VSUP*1' 2.285050000000e-04 'VSUP*0' 2.290000000000e-04 'VSUP*0' 2.290050000000e-04 'VSUP*1' 2.295000000000e-04 'VSUP*1' 2.295050000000e-04 'VSUP*0' 2.300000000000e-04 'VSUP*0' 2.300050000000e-04 'VSUP*1' 2.305000000000e-04 'VSUP*1' 2.305050000000e-04 'VSUP*0' 2.310000000000e-04 'VSUP*0' 2.310050000000e-04 'VSUP*1' 2.315000000000e-04 'VSUP*1' 2.315050000000e-04 'VSUP*0' 2.320000000000e-04 'VSUP*0' 2.320050000000e-04 'VSUP*1' 2.325000000000e-04 'VSUP*1' 2.325050000000e-04 'VSUP*0' 2.330000000000e-04 'VSUP*0' 2.330050000000e-04 'VSUP*1' 2.335000000000e-04 'VSUP*1' 2.335050000000e-04 'VSUP*0' 2.340000000000e-04 'VSUP*0' 2.340050000000e-04 'VSUP*1' 2.345000000000e-04 'VSUP*1' 2.345050000000e-04 'VSUP*0' 2.350000000000e-04 'VSUP*0' 2.350050000000e-04 'VSUP*1' 2.355000000000e-04 'VSUP*1' 2.355050000000e-04 'VSUP*0' 2.360000000000e-04 'VSUP*0' 2.360050000000e-04 'VSUP*1' 2.365000000000e-04 'VSUP*1' 2.365050000000e-04 'VSUP*0' 2.370000000000e-04 'VSUP*0' 2.370050000000e-04 'VSUP*1' 2.375000000000e-04 'VSUP*1' 2.375050000000e-04 'VSUP*0' 2.380000000000e-04 'VSUP*0' 2.380050000000e-04 'VSUP*1' 2.385000000000e-04 'VSUP*1' 2.385050000000e-04 'VSUP*0' 2.390000000000e-04 'VSUP*0' 2.390050000000e-04 'VSUP*1' 2.395000000000e-04 'VSUP*1' 2.395050000000e-04 'VSUP*0' 2.400000000000e-04 'VSUP*0' 2.400050000000e-04 'VSUP*1' 2.405000000000e-04 'VSUP*1' 2.405050000000e-04 'VSUP*0' 2.410000000000e-04 'VSUP*0' 2.410050000000e-04 'VSUP*1' 2.415000000000e-04 'VSUP*1' 2.415050000000e-04 'VSUP*0' 2.420000000000e-04 'VSUP*0' 2.420050000000e-04 'VSUP*1' 2.425000000000e-04 'VSUP*1' 2.425050000000e-04 'VSUP*0' 2.430000000000e-04 'VSUP*0' 2.430050000000e-04 'VSUP*1' 2.435000000000e-04 'VSUP*1' 2.435050000000e-04 'VSUP*0' 2.440000000000e-04 'VSUP*0' 2.440050000000e-04 'VSUP*1' 2.445000000000e-04 'VSUP*1' 2.445050000000e-04 'VSUP*0' 2.450000000000e-04 'VSUP*0' 2.450050000000e-04 'VSUP*1' 2.455000000000e-04 'VSUP*1' 2.455050000000e-04 'VSUP*0' 2.460000000000e-04 'VSUP*0' 2.460050000000e-04 'VSUP*1' 2.465000000000e-04 'VSUP*1' 2.465050000000e-04 'VSUP*0' 2.470000000000e-04 'VSUP*0' 2.470050000000e-04 'VSUP*1' 2.475000000000e-04 'VSUP*1' 2.475050000000e-04 'VSUP*0' 2.480000000000e-04 'VSUP*0' 2.480050000000e-04 'VSUP*1' 2.485000000000e-04 'VSUP*1' 2.485050000000e-04 'VSUP*0' 2.490000000000e-04 'VSUP*0' 2.490050000000e-04 'VSUP*1' 2.495000000000e-04 'VSUP*1' 2.495050000000e-04 'VSUP*0' 2.500000000000e-04 'VSUP*0' 2.500050000000e-04 'VSUP*1' 2.505000000000e-04 'VSUP*1' 2.505050000000e-04 'VSUP*0' 2.510000000000e-04 'VSUP*0' 2.510050000000e-04 'VSUP*1' 2.515000000000e-04 'VSUP*1' 2.515050000000e-04 'VSUP*0' 2.520000000000e-04 'VSUP*0' 2.520050000000e-04 'VSUP*1' 2.525000000000e-04 'VSUP*1' 2.525050000000e-04 'VSUP*0' 2.530000000000e-04 'VSUP*0' 2.530050000000e-04 'VSUP*1' 2.535000000000e-04 'VSUP*1' 2.535050000000e-04 'VSUP*0' 2.540000000000e-04 'VSUP*0' 2.540050000000e-04 'VSUP*1' 2.545000000000e-04 'VSUP*1' 2.545050000000e-04 'VSUP*0' 2.550000000000e-04 'VSUP*0' 2.550050000000e-04 'VSUP*1' 2.555000000000e-04 'VSUP*1' 2.555050000000e-04 'VSUP*0' 2.560000000000e-04 'VSUP*0' 2.560050000000e-04 'VSUP*1' 2.565000000000e-04 'VSUP*1' 2.565050000000e-04 'VSUP*0' 2.570000000000e-04 'VSUP*0' 2.570050000000e-04 'VSUP*1' 2.575000000000e-04 'VSUP*1' 2.575050000000e-04 'VSUP*0' 2.580000000000e-04 'VSUP*0' 2.580050000000e-04 'VSUP*1' 2.585000000000e-04 'VSUP*1' 2.585050000000e-04 'VSUP*0' 2.590000000000e-04 'VSUP*0' 2.590050000000e-04 'VSUP*1' 2.595000000000e-04 'VSUP*1' 2.595050000000e-04 'VSUP*0' 2.600000000000e-04 'VSUP*0' 2.600050000000e-04 'VSUP*1' 2.605000000000e-04 'VSUP*1' 2.605050000000e-04 'VSUP*0' 2.610000000000e-04 'VSUP*0' 2.610050000000e-04 'VSUP*1' 2.615000000000e-04 'VSUP*1' 2.615050000000e-04 'VSUP*0' 2.620000000000e-04 'VSUP*0' 2.620050000000e-04 'VSUP*1' 2.625000000000e-04 'VSUP*1' 2.625050000000e-04 'VSUP*0' 2.630000000000e-04 'VSUP*0' 2.630050000000e-04 'VSUP*1' 2.635000000000e-04 'VSUP*1' 2.635050000000e-04 'VSUP*0' 2.640000000000e-04 'VSUP*0' 2.640050000000e-04 'VSUP*1' 2.645000000000e-04 'VSUP*1' 2.645050000000e-04 'VSUP*0' 2.650000000000e-04 'VSUP*0' 2.650050000000e-04 'VSUP*1' 2.655000000000e-04 'VSUP*1' 2.655050000000e-04 'VSUP*0' 2.660000000000e-04 'VSUP*0' 2.660050000000e-04 'VSUP*1' 2.665000000000e-04 'VSUP*1' 2.665050000000e-04 'VSUP*0' 2.670000000000e-04 'VSUP*0' 2.670050000000e-04 'VSUP*1' 2.675000000000e-04 'VSUP*1' 2.675050000000e-04 'VSUP*0' 2.680000000000e-04 'VSUP*0' 2.680050000000e-04 'VSUP*1' 2.685000000000e-04 'VSUP*1' 2.685050000000e-04 'VSUP*0' 2.690000000000e-04 'VSUP*0' 2.690050000000e-04 'VSUP*1' 2.695000000000e-04 'VSUP*1' 2.695050000000e-04 'VSUP*0' 2.700000000000e-04 'VSUP*0' 2.700050000000e-04 'VSUP*1' 2.705000000000e-04 'VSUP*1' 2.705050000000e-04 'VSUP*0' 2.710000000000e-04 'VSUP*0' 2.710050000000e-04 'VSUP*1' 2.715000000000e-04 'VSUP*1' 2.715050000000e-04 'VSUP*0' 2.720000000000e-04 'VSUP*0' 2.720050000000e-04 'VSUP*1' 2.725000000000e-04 'VSUP*1' 2.725050000000e-04 'VSUP*0' 2.730000000000e-04 'VSUP*0' 2.730050000000e-04 'VSUP*1' 2.735000000000e-04 'VSUP*1' 2.735050000000e-04 'VSUP*0' 2.740000000000e-04 'VSUP*0' 2.740050000000e-04 'VSUP*1' 2.745000000000e-04 'VSUP*1' 2.745050000000e-04 'VSUP*0' 2.750000000000e-04 'VSUP*0' 2.750050000000e-04 'VSUP*1' 2.755000000000e-04 'VSUP*1' 2.755050000000e-04 'VSUP*0' 2.760000000000e-04 'VSUP*0' 2.760050000000e-04 'VSUP*1' 2.765000000000e-04 'VSUP*1' 2.765050000000e-04 'VSUP*0' 2.770000000000e-04 'VSUP*0' 2.770050000000e-04 'VSUP*1' 2.775000000000e-04 'VSUP*1' 2.775050000000e-04 'VSUP*0' 2.780000000000e-04 'VSUP*0' 2.780050000000e-04 'VSUP*1' 2.785000000000e-04 'VSUP*1' 2.785050000000e-04 'VSUP*0' 2.790000000000e-04 'VSUP*0' 2.790050000000e-04 'VSUP*1' 2.795000000000e-04 'VSUP*1' 2.795050000000e-04 'VSUP*0' 2.800000000000e-04 'VSUP*0' 2.800050000000e-04 'VSUP*1' 2.805000000000e-04 'VSUP*1' 2.805050000000e-04 'VSUP*0' 2.810000000000e-04 'VSUP*0' 2.810050000000e-04 'VSUP*1' 2.815000000000e-04 'VSUP*1' 2.815050000000e-04 'VSUP*0' 2.820000000000e-04 'VSUP*0' 2.820050000000e-04 'VSUP*1' 2.825000000000e-04 'VSUP*1' 2.825050000000e-04 'VSUP*0' 2.830000000000e-04 'VSUP*0' 2.830050000000e-04 'VSUP*1' 2.835000000000e-04 'VSUP*1' 2.835050000000e-04 'VSUP*0' 2.840000000000e-04 'VSUP*0' 2.840050000000e-04 'VSUP*1' 2.845000000000e-04 'VSUP*1' 2.845050000000e-04 'VSUP*0' 2.850000000000e-04 'VSUP*0' 2.850050000000e-04 'VSUP*1' 2.855000000000e-04 'VSUP*1' 2.855050000000e-04 'VSUP*0' 2.860000000000e-04 'VSUP*0' 2.860050000000e-04 'VSUP*1' 2.865000000000e-04 'VSUP*1' 2.865050000000e-04 'VSUP*0' 2.870000000000e-04 'VSUP*0' 2.870050000000e-04 'VSUP*1' 2.875000000000e-04 'VSUP*1' 2.875050000000e-04 'VSUP*0' 2.880000000000e-04 'VSUP*0' 2.880050000000e-04 'VSUP*1' 2.885000000000e-04 'VSUP*1' 2.885050000000e-04 'VSUP*0' 2.890000000000e-04 'VSUP*0' 2.890050000000e-04 'VSUP*1' 2.895000000000e-04 'VSUP*1' 2.895050000000e-04 'VSUP*0')"}
C {devices/lab_pin.sym} -500 3870 0 0 {name=l370 lab=CLK}
C {devices/lab_pin.sym} -500 3930 0 0 {name=l371 lab=0}
T {CLK stimulus} -600 3720 0 0 0.3 0.3 {}
C {devices/vsource.sym} 100 3900 0 0 {name=VRESET value="PWL(0.000000000000e+00 'VSUP*0' 5.000000000000e-09 'VSUP*1' 7.500000000000e-07 'VSUP*1' 7.550000000000e-07 'VSUP*0')"}
C {devices/lab_pin.sym} 100 3870 0 0 {name=l374 lab=RESET}
C {devices/lab_pin.sym} 100 3930 0 0 {name=l375 lab=0}
T {RESET stimulus} 0 3720 0 0 0.3 0.3 {}
C {devices/vsource.sym} 700 3900 0 0 {name=VSDI value="PWL(0.000000000000e+00 'VSUP*0' 1.750000000000e-06 'VSUP*0' 1.755000000000e-06 'VSUP*0' 2.750000000000e-06 'VSUP*0' 2.755000000000e-06 'VSUP*0' 3.750000000000e-06 'VSUP*0' 3.755000000000e-06 'VSUP*0' 4.750000000000e-06 'VSUP*0' 4.755000000000e-06 'VSUP*0' 5.750000000000e-06 'VSUP*0' 5.755000000000e-06 'VSUP*0' 6.750000000000e-06 'VSUP*0' 6.755000000000e-06 'VSUP*0' 7.750000000000e-06 'VSUP*0' 7.755000000000e-06 'VSUP*0' 8.750000000000e-06 'VSUP*0' 8.755000000000e-06 'VSUP*0' 9.750000000000e-06 'VSUP*0' 9.755000000000e-06 'VSUP*0' 1.075000000000e-05 'VSUP*0' 1.075500000000e-05 'VSUP*0' 1.175000000000e-05 'VSUP*0' 1.175500000000e-05 'VSUP*0' 1.275000000000e-05 'VSUP*0' 1.275500000000e-05 'VSUP*1' 1.375000000000e-05 'VSUP*1' 1.375500000000e-05 'VSUP*0' 1.475000000000e-05 'VSUP*0' 1.475500000000e-05 'VSUP*1' 1.575000000000e-05 'VSUP*1' 1.575500000000e-05 'VSUP*0' 1.675000000000e-05 'VSUP*0' 1.675500000000e-05 'VSUP*1' 1.775000000000e-05 'VSUP*1' 1.775500000000e-05 'VSUP*0' 1.875000000000e-05 'VSUP*0' 1.875500000000e-05 'VSUP*1' 1.975000000000e-05 'VSUP*1' 1.975500000000e-05 'VSUP*0' 2.075000000000e-05 'VSUP*0' 2.075500000000e-05 'VSUP*0' 2.175000000000e-05 'VSUP*0' 2.175500000000e-05 'VSUP*0' 2.275000000000e-05 'VSUP*0' 2.275500000000e-05 'VSUP*0' 2.375000000000e-05 'VSUP*0' 2.375500000000e-05 'VSUP*1' 2.475000000000e-05 'VSUP*1' 2.475500000000e-05 'VSUP*1' 2.575000000000e-05 'VSUP*1' 2.575500000000e-05 'VSUP*1' 2.675000000000e-05 'VSUP*1' 2.675500000000e-05 'VSUP*1' 2.775000000000e-05 'VSUP*1' 2.775500000000e-05 'VSUP*1' 2.875000000000e-05 'VSUP*1' 2.875500000000e-05 'VSUP*1' 2.975000000000e-05 'VSUP*1' 2.975500000000e-05 'VSUP*0' 3.075000000000e-05 'VSUP*0' 3.075500000000e-05 'VSUP*1' 3.175000000000e-05 'VSUP*1' 3.175500000000e-05 'VSUP*0' 3.275000000000e-05 'VSUP*0' 3.275500000000e-05 'VSUP*1' 3.375000000000e-05 'VSUP*1' 3.375500000000e-05 'VSUP*0' 3.475000000000e-05 'VSUP*0' 3.475500000000e-05 'VSUP*1' 3.575000000000e-05 'VSUP*1' 3.575500000000e-05 'VSUP*0' 3.675000000000e-05 'VSUP*0' 3.675500000000e-05 'VSUP*1' 3.775000000000e-05 'VSUP*1' 3.775500000000e-05 'VSUP*1' 3.875000000000e-05 'VSUP*1' 3.875500000000e-05 'VSUP*1' 3.975000000000e-05 'VSUP*1' 3.975500000000e-05 'VSUP*1' 4.075000000000e-05 'VSUP*1' 4.075500000000e-05 'VSUP*1' 4.175000000000e-05 'VSUP*1' 4.175500000000e-05 'VSUP*0' 4.275000000000e-05 'VSUP*0' 4.275500000000e-05 'VSUP*0' 4.375000000000e-05 'VSUP*0' 4.375500000000e-05 'VSUP*0' 4.475000000000e-05 'VSUP*0' 4.475500000000e-05 'VSUP*0' 4.575000000000e-05 'VSUP*0' 4.575500000000e-05 'VSUP*0' 4.675000000000e-05 'VSUP*0' 4.675500000000e-05 'VSUP*1' 4.775000000000e-05 'VSUP*1' 4.775500000000e-05 'VSUP*0' 4.875000000000e-05 'VSUP*0' 4.875500000000e-05 'VSUP*1' 4.975000000000e-05 'VSUP*1' 4.975500000000e-05 'VSUP*0' 5.075000000000e-05 'VSUP*0' 5.075500000000e-05 'VSUP*1' 5.175000000000e-05 'VSUP*1' 5.175500000000e-05 'VSUP*0' 5.275000000000e-05 'VSUP*0' 5.275500000000e-05 'VSUP*1' 5.375000000000e-05 'VSUP*1' 5.375500000000e-05 'VSUP*0' 5.475000000000e-05 'VSUP*0' 5.475500000000e-05 'VSUP*1' 5.575000000000e-05 'VSUP*1' 5.575500000000e-05 'VSUP*1' 5.675000000000e-05 'VSUP*1' 5.675500000000e-05 'VSUP*1' 5.775000000000e-05 'VSUP*1' 5.775500000000e-05 'VSUP*1' 5.875000000000e-05 'VSUP*1' 5.875500000000e-05 'VSUP*1' 5.975000000000e-05 'VSUP*1' 5.975500000000e-05 'VSUP*1' 6.075000000000e-05 'VSUP*1' 6.075500000000e-05 'VSUP*1' 6.175000000000e-05 'VSUP*1' 6.175500000000e-05 'VSUP*1' 6.275000000000e-05 'VSUP*1' 6.275500000000e-05 'VSUP*1' 6.375000000000e-05 'VSUP*1' 6.375500000000e-05 'VSUP*1' 6.475000000000e-05 'VSUP*1' 6.475500000000e-05 'VSUP*0' 6.575000000000e-05 'VSUP*0' 6.575500000000e-05 'VSUP*0' 6.675000000000e-05 'VSUP*0' 6.675500000000e-05 'VSUP*1' 6.775000000000e-05 'VSUP*1' 6.775500000000e-05 'VSUP*0' 6.875000000000e-05 'VSUP*0' 6.875500000000e-05 'VSUP*1' 6.975000000000e-05 'VSUP*1' 6.975500000000e-05 'VSUP*0' 7.075000000000e-05 'VSUP*0' 7.075500000000e-05 'VSUP*1' 7.175000000000e-05 'VSUP*1' 7.175500000000e-05 'VSUP*0' 7.275000000000e-05 'VSUP*0' 7.275500000000e-05 'VSUP*1' 7.375000000000e-05 'VSUP*1' 7.375500000000e-05 'VSUP*0' 7.475000000000e-05 'VSUP*0' 7.475500000000e-05 'VSUP*0' 7.575000000000e-05 'VSUP*0' 7.575500000000e-05 'VSUP*0' 7.675000000000e-05 'VSUP*0' 7.675500000000e-05 'VSUP*0' 7.775000000000e-05 'VSUP*0' 7.775500000000e-05 'VSUP*0' 7.875000000000e-05 'VSUP*0' 7.875500000000e-05 'VSUP*0' 7.975000000000e-05 'VSUP*0' 7.975500000000e-05 'VSUP*0' 8.075000000000e-05 'VSUP*0' 8.075500000000e-05 'VSUP*0' 8.175000000000e-05 'VSUP*0' 8.175500000000e-05 'VSUP*0' 8.275000000000e-05 'VSUP*0' 8.275500000000e-05 'VSUP*0' 8.375000000000e-05 'VSUP*0' 8.375500000000e-05 'VSUP*0' 8.475000000000e-05 'VSUP*0' 8.475500000000e-05 'VSUP*1' 8.575000000000e-05 'VSUP*1' 8.575500000000e-05 'VSUP*0' 8.675000000000e-05 'VSUP*0' 8.675500000000e-05 'VSUP*1' 8.775000000000e-05 'VSUP*1' 8.775500000000e-05 'VSUP*0' 8.875000000000e-05 'VSUP*0' 8.875500000000e-05 'VSUP*1' 8.975000000000e-05 'VSUP*1' 8.975500000000e-05 'VSUP*0' 9.075000000000e-05 'VSUP*0' 9.075500000000e-05 'VSUP*1' 9.175000000000e-05 'VSUP*1' 9.175500000000e-05 'VSUP*0' 9.275000000000e-05 'VSUP*0' 9.275500000000e-05 'VSUP*0' 9.375000000000e-05 'VSUP*0' 9.375500000000e-05 'VSUP*0' 9.475000000000e-05 'VSUP*0' 9.475500000000e-05 'VSUP*0' 9.575000000000e-05 'VSUP*0' 9.575500000000e-05 'VSUP*1' 9.675000000000e-05 'VSUP*1' 9.675500000000e-05 'VSUP*1' 9.775000000000e-05 'VSUP*1' 9.775500000000e-05 'VSUP*1' 9.875000000000e-05 'VSUP*1' 9.875500000000e-05 'VSUP*1' 9.975000000000e-05 'VSUP*1' 9.975500000000e-05 'VSUP*1' 1.007500000000e-04 'VSUP*1' 1.007550000000e-04 'VSUP*0' 1.017500000000e-04 'VSUP*0' 1.017550000000e-04 'VSUP*0' 1.027500000000e-04 'VSUP*0' 1.027550000000e-04 'VSUP*1' 1.037500000000e-04 'VSUP*1' 1.037550000000e-04 'VSUP*0' 1.047500000000e-04 'VSUP*0' 1.047550000000e-04 'VSUP*1' 1.057500000000e-04 'VSUP*1' 1.057550000000e-04 'VSUP*0' 1.067500000000e-04 'VSUP*0' 1.067550000000e-04 'VSUP*1' 1.077500000000e-04 'VSUP*1' 1.077550000000e-04 'VSUP*0' 1.087500000000e-04 'VSUP*0' 1.087550000000e-04 'VSUP*1' 1.097500000000e-04 'VSUP*1' 1.097550000000e-04 'VSUP*1' 1.107500000000e-04 'VSUP*1' 1.107550000000e-04 'VSUP*1' 1.117500000000e-04 'VSUP*1' 1.117550000000e-04 'VSUP*1' 1.127500000000e-04 'VSUP*1' 1.127550000000e-04 'VSUP*1' 1.137500000000e-04 'VSUP*1' 1.137550000000e-04 'VSUP*0' 1.147500000000e-04 'VSUP*0' 1.147550000000e-04 'VSUP*0' 1.157500000000e-04 'VSUP*0' 1.157550000000e-04 'VSUP*0' 1.167500000000e-04 'VSUP*0' 1.167550000000e-04 'VSUP*0' 1.177500000000e-04 'VSUP*0' 1.177550000000e-04 'VSUP*0' 1.187500000000e-04 'VSUP*0' 1.187550000000e-04 'VSUP*0' 1.197500000000e-04 'VSUP*0' 1.197550000000e-04 'VSUP*0' 1.207500000000e-04 'VSUP*0' 1.207550000000e-04 'VSUP*1' 1.217500000000e-04 'VSUP*1' 1.217550000000e-04 'VSUP*0' 1.227500000000e-04 'VSUP*0' 1.227550000000e-04 'VSUP*1' 1.237500000000e-04 'VSUP*1' 1.237550000000e-04 'VSUP*0' 1.247500000000e-04 'VSUP*0' 1.247550000000e-04 'VSUP*1' 1.257500000000e-04 'VSUP*1' 1.257550000000e-04 'VSUP*0' 1.267500000000e-04 'VSUP*0' 1.267550000000e-04 'VSUP*1' 1.277500000000e-04 'VSUP*1' 1.277550000000e-04 'VSUP*1' 1.287500000000e-04 'VSUP*1' 1.287550000000e-04 'VSUP*1' 1.297500000000e-04 'VSUP*1' 1.297550000000e-04 'VSUP*1' 1.307500000000e-04 'VSUP*1' 1.307550000000e-04 'VSUP*1' 1.317500000000e-04 'VSUP*1' 1.317550000000e-04 'VSUP*1' 1.327500000000e-04 'VSUP*1' 1.327550000000e-04 'VSUP*1' 1.337500000000e-04 'VSUP*1' 1.337550000000e-04 'VSUP*1' 1.347500000000e-04 'VSUP*1' 1.347550000000e-04 'VSUP*1' 1.357500000000e-04 'VSUP*1' 1.357550000000e-04 'VSUP*1' 1.367500000000e-04 'VSUP*1' 1.367550000000e-04 'VSUP*0' 1.377500000000e-04 'VSUP*0' 1.377550000000e-04 'VSUP*0' 1.387500000000e-04 'VSUP*0' 1.387550000000e-04 'VSUP*1' 1.397500000000e-04 'VSUP*1' 1.397550000000e-04 'VSUP*0' 1.407500000000e-04 'VSUP*0' 1.407550000000e-04 'VSUP*1' 1.417500000000e-04 'VSUP*1' 1.417550000000e-04 'VSUP*0' 1.427500000000e-04 'VSUP*0' 1.427550000000e-04 'VSUP*1' 1.437500000000e-04 'VSUP*1' 1.437550000000e-04 'VSUP*0' 1.447500000000e-04 'VSUP*0' 1.447550000000e-04 'VSUP*1' 1.457500000000e-04 'VSUP*1' 1.457550000000e-04 'VSUP*0' 1.467500000000e-04 'VSUP*0' 1.467550000000e-04 'VSUP*0' 1.477500000000e-04 'VSUP*0' 1.477550000000e-04 'VSUP*0' 1.487500000000e-04 'VSUP*0' 1.487550000000e-04 'VSUP*0' 1.497500000000e-04 'VSUP*0' 1.497550000000e-04 'VSUP*0' 1.507500000000e-04 'VSUP*0' 1.507550000000e-04 'VSUP*0' 1.517500000000e-04 'VSUP*0' 1.517550000000e-04 'VSUP*0' 1.527500000000e-04 'VSUP*0' 1.527550000000e-04 'VSUP*0' 1.537500000000e-04 'VSUP*0' 1.537550000000e-04 'VSUP*0' 1.547500000000e-04 'VSUP*0' 1.547550000000e-04 'VSUP*1' 1.557500000000e-04 'VSUP*1' 1.557550000000e-04 'VSUP*0' 1.567500000000e-04 'VSUP*0' 1.567550000000e-04 'VSUP*1' 1.577500000000e-04 'VSUP*1' 1.577550000000e-04 'VSUP*0' 1.587500000000e-04 'VSUP*0' 1.587550000000e-04 'VSUP*1' 1.597500000000e-04 'VSUP*1' 1.597550000000e-04 'VSUP*0' 1.607500000000e-04 'VSUP*0' 1.607550000000e-04 'VSUP*1' 1.617500000000e-04 'VSUP*1' 1.617550000000e-04 'VSUP*0' 1.627500000000e-04 'VSUP*0' 1.627550000000e-04 'VSUP*1' 1.637500000000e-04 'VSUP*1' 1.637550000000e-04 'VSUP*0' 1.647500000000e-04 'VSUP*0' 1.647550000000e-04 'VSUP*0' 1.657500000000e-04 'VSUP*0' 1.657550000000e-04 'VSUP*0' 1.667500000000e-04 'VSUP*0' 1.667550000000e-04 'VSUP*0' 1.677500000000e-04 'VSUP*0' 1.677550000000e-04 'VSUP*1' 1.687500000000e-04 'VSUP*1' 1.687550000000e-04 'VSUP*1' 1.697500000000e-04 'VSUP*1' 1.697550000000e-04 'VSUP*1' 1.707500000000e-04 'VSUP*1' 1.707550000000e-04 'VSUP*1' 1.717500000000e-04 'VSUP*1' 1.717550000000e-04 'VSUP*1' 1.727500000000e-04 'VSUP*1' 1.727550000000e-04 'VSUP*0' 1.737500000000e-04 'VSUP*0' 1.737550000000e-04 'VSUP*0' 1.747500000000e-04 'VSUP*0' 1.747550000000e-04 'VSUP*1' 1.757500000000e-04 'VSUP*1' 1.757550000000e-04 'VSUP*0' 1.767500000000e-04 'VSUP*0' 1.767550000000e-04 'VSUP*1' 1.777500000000e-04 'VSUP*1' 1.777550000000e-04 'VSUP*0' 1.787500000000e-04 'VSUP*0' 1.787550000000e-04 'VSUP*1' 1.797500000000e-04 'VSUP*1' 1.797550000000e-04 'VSUP*0' 1.807500000000e-04 'VSUP*0' 1.807550000000e-04 'VSUP*1' 1.817500000000e-04 'VSUP*1' 1.817550000000e-04 'VSUP*1' 1.827500000000e-04 'VSUP*1' 1.827550000000e-04 'VSUP*1' 1.837500000000e-04 'VSUP*1' 1.837550000000e-04 'VSUP*1' 1.847500000000e-04 'VSUP*1' 1.847550000000e-04 'VSUP*1' 1.857500000000e-04 'VSUP*1' 1.857550000000e-04 'VSUP*0' 1.867500000000e-04 'VSUP*0' 1.867550000000e-04 'VSUP*0' 1.877500000000e-04 'VSUP*0' 1.877550000000e-04 'VSUP*0' 1.887500000000e-04 'VSUP*0' 1.887550000000e-04 'VSUP*0' 1.897500000000e-04 'VSUP*0' 1.897550000000e-04 'VSUP*0' 1.907500000000e-04 'VSUP*0' 1.907550000000e-04 'VSUP*0' 1.917500000000e-04 'VSUP*0' 1.917550000000e-04 'VSUP*0' 1.927500000000e-04 'VSUP*0' 1.927550000000e-04 'VSUP*1' 1.937500000000e-04 'VSUP*1' 1.937550000000e-04 'VSUP*0' 1.947500000000e-04 'VSUP*0' 1.947550000000e-04 'VSUP*1' 1.957500000000e-04 'VSUP*1' 1.957550000000e-04 'VSUP*0' 1.967500000000e-04 'VSUP*0' 1.967550000000e-04 'VSUP*1' 1.977500000000e-04 'VSUP*1' 1.977550000000e-04 'VSUP*0' 1.987500000000e-04 'VSUP*0' 1.987550000000e-04 'VSUP*1' 1.997500000000e-04 'VSUP*1' 1.997550000000e-04 'VSUP*1' 2.007500000000e-04 'VSUP*1' 2.007550000000e-04 'VSUP*1' 2.017500000000e-04 'VSUP*1' 2.017550000000e-04 'VSUP*1' 2.027500000000e-04 'VSUP*1' 2.027550000000e-04 'VSUP*1' 2.037500000000e-04 'VSUP*1' 2.037550000000e-04 'VSUP*1' 2.047500000000e-04 'VSUP*1' 2.047550000000e-04 'VSUP*1' 2.057500000000e-04 'VSUP*1' 2.057550000000e-04 'VSUP*1' 2.067500000000e-04 'VSUP*1' 2.067550000000e-04 'VSUP*1' 2.077500000000e-04 'VSUP*1' 2.077550000000e-04 'VSUP*1' 2.087500000000e-04 'VSUP*1' 2.087550000000e-04 'VSUP*1' 2.097500000000e-04 'VSUP*1' 2.097550000000e-04 'VSUP*0' 2.107500000000e-04 'VSUP*0' 2.107550000000e-04 'VSUP*1' 2.117500000000e-04 'VSUP*1' 2.117550000000e-04 'VSUP*0' 2.127500000000e-04 'VSUP*0' 2.127550000000e-04 'VSUP*1' 2.137500000000e-04 'VSUP*1' 2.137550000000e-04 'VSUP*0' 2.147500000000e-04 'VSUP*0' 2.147550000000e-04 'VSUP*1' 2.157500000000e-04 'VSUP*1' 2.157550000000e-04 'VSUP*0' 2.167500000000e-04 'VSUP*0' 2.167550000000e-04 'VSUP*1' 2.177500000000e-04 'VSUP*1' 2.177550000000e-04 'VSUP*0' 2.187500000000e-04 'VSUP*0' 2.187550000000e-04 'VSUP*0' 2.197500000000e-04 'VSUP*0' 2.197550000000e-04 'VSUP*0' 2.207500000000e-04 'VSUP*0' 2.207550000000e-04 'VSUP*0' 2.217500000000e-04 'VSUP*0' 2.217550000000e-04 'VSUP*0' 2.227500000000e-04 'VSUP*0' 2.227550000000e-04 'VSUP*0' 2.237500000000e-04 'VSUP*0' 2.237550000000e-04 'VSUP*0' 2.247500000000e-04 'VSUP*0' 2.247550000000e-04 'VSUP*0' 2.257500000000e-04 'VSUP*0' 2.257550000000e-04 'VSUP*0' 2.267500000000e-04 'VSUP*0' 2.267550000000e-04 'VSUP*0' 2.277500000000e-04 'VSUP*0' 2.277550000000e-04 'VSUP*0' 2.287500000000e-04 'VSUP*0' 2.287550000000e-04 'VSUP*1' 2.297500000000e-04 'VSUP*1' 2.297550000000e-04 'VSUP*0' 2.307500000000e-04 'VSUP*0' 2.307550000000e-04 'VSUP*1' 2.317500000000e-04 'VSUP*1' 2.317550000000e-04 'VSUP*0' 2.327500000000e-04 'VSUP*0' 2.327550000000e-04 'VSUP*1' 2.337500000000e-04 'VSUP*1' 2.337550000000e-04 'VSUP*0' 2.347500000000e-04 'VSUP*0' 2.347550000000e-04 'VSUP*1' 2.357500000000e-04 'VSUP*1' 2.357550000000e-04 'VSUP*0' 2.367500000000e-04 'VSUP*0' 2.367550000000e-04 'VSUP*0' 2.377500000000e-04 'VSUP*0' 2.377550000000e-04 'VSUP*0' 2.387500000000e-04 'VSUP*0' 2.387550000000e-04 'VSUP*0' 2.397500000000e-04 'VSUP*0' 2.397550000000e-04 'VSUP*1' 2.407500000000e-04 'VSUP*1' 2.407550000000e-04 'VSUP*1' 2.417500000000e-04 'VSUP*1' 2.417550000000e-04 'VSUP*1' 2.427500000000e-04 'VSUP*1' 2.427550000000e-04 'VSUP*1' 2.437500000000e-04 'VSUP*1' 2.437550000000e-04 'VSUP*1' 2.447500000000e-04 'VSUP*1' 2.447550000000e-04 'VSUP*0' 2.457500000000e-04 'VSUP*0' 2.457550000000e-04 'VSUP*0' 2.467500000000e-04 'VSUP*0' 2.467550000000e-04 'VSUP*1' 2.477500000000e-04 'VSUP*1' 2.477550000000e-04 'VSUP*0' 2.487500000000e-04 'VSUP*0' 2.487550000000e-04 'VSUP*1' 2.497500000000e-04 'VSUP*1' 2.497550000000e-04 'VSUP*0' 2.507500000000e-04 'VSUP*0' 2.507550000000e-04 'VSUP*1' 2.517500000000e-04 'VSUP*1' 2.517550000000e-04 'VSUP*0' 2.527500000000e-04 'VSUP*0' 2.527550000000e-04 'VSUP*1' 2.537500000000e-04 'VSUP*1' 2.537550000000e-04 'VSUP*1' 2.547500000000e-04 'VSUP*1' 2.547550000000e-04 'VSUP*1' 2.557500000000e-04 'VSUP*1' 2.557550000000e-04 'VSUP*1' 2.567500000000e-04 'VSUP*1' 2.567550000000e-04 'VSUP*1' 2.577500000000e-04 'VSUP*1' 2.577550000000e-04 'VSUP*0' 2.587500000000e-04 'VSUP*0' 2.587550000000e-04 'VSUP*0' 2.597500000000e-04 'VSUP*0' 2.597550000000e-04 'VSUP*0' 2.607500000000e-04 'VSUP*0' 2.607550000000e-04 'VSUP*0' 2.617500000000e-04 'VSUP*0' 2.617550000000e-04 'VSUP*0' 2.627500000000e-04 'VSUP*0' 2.627550000000e-04 'VSUP*0' 2.637500000000e-04 'VSUP*0' 2.637550000000e-04 'VSUP*0' 2.647500000000e-04 'VSUP*0' 2.647550000000e-04 'VSUP*1' 2.657500000000e-04 'VSUP*1' 2.657550000000e-04 'VSUP*0' 2.667500000000e-04 'VSUP*0' 2.667550000000e-04 'VSUP*1' 2.677500000000e-04 'VSUP*1' 2.677550000000e-04 'VSUP*0' 2.687500000000e-04 'VSUP*0' 2.687550000000e-04 'VSUP*1' 2.697500000000e-04 'VSUP*1' 2.697550000000e-04 'VSUP*0' 2.707500000000e-04 'VSUP*0' 2.707550000000e-04 'VSUP*1' 2.717500000000e-04 'VSUP*1' 2.717550000000e-04 'VSUP*1' 2.727500000000e-04 'VSUP*1' 2.727550000000e-04 'VSUP*1' 2.737500000000e-04 'VSUP*1' 2.737550000000e-04 'VSUP*1' 2.747500000000e-04 'VSUP*1' 2.747550000000e-04 'VSUP*1' 2.757500000000e-04 'VSUP*1' 2.757550000000e-04 'VSUP*1' 2.767500000000e-04 'VSUP*1' 2.767550000000e-04 'VSUP*1' 2.777500000000e-04 'VSUP*1' 2.777550000000e-04 'VSUP*1' 2.787500000000e-04 'VSUP*1' 2.787550000000e-04 'VSUP*1' 2.797500000000e-04 'VSUP*1' 2.797550000000e-04 'VSUP*1' 2.807500000000e-04 'VSUP*1' 2.807550000000e-04 'VSUP*0' 2.817500000000e-04 'VSUP*0' 2.817550000000e-04 'VSUP*0' 2.827500000000e-04 'VSUP*0' 2.827550000000e-04 'VSUP*1' 2.837500000000e-04 'VSUP*1' 2.837550000000e-04 'VSUP*0' 2.847500000000e-04 'VSUP*0' 2.847550000000e-04 'VSUP*1' 2.857500000000e-04 'VSUP*1' 2.857550000000e-04 'VSUP*0' 2.867500000000e-04 'VSUP*0' 2.867550000000e-04 'VSUP*1' 2.877500000000e-04 'VSUP*1' 2.877550000000e-04 'VSUP*0' 2.887500000000e-04 'VSUP*0' 2.887550000000e-04 'VSUP*1')"}
C {devices/lab_pin.sym} 700 3870 0 0 {name=l378 lab=SDI}
C {devices/lab_pin.sym} 700 3930 0 0 {name=l379 lab=0}
T {SDI stimulus} 600 3720 0 0 0.3 0.3 {}
C {devices/vsource.sym} 1300 3900 0 0 {name=VWE value="PWL(0.000000000000e+00 'VSUP*0' 1.700000000000e-06 'VSUP*0' 1.705000000000e-06 'VSUP*1' 1.230000000000e-05 'VSUP*1' 1.230500000000e-05 'VSUP*0' 1.970000000000e-05 'VSUP*0' 1.970500000000e-05 'VSUP*1' 3.030000000000e-05 'VSUP*1' 3.030500000000e-05 'VSUP*0' 3.770000000000e-05 'VSUP*0' 3.770500000000e-05 'VSUP*1' 4.830000000000e-05 'VSUP*1' 4.830500000000e-05 'VSUP*0' 5.570000000000e-05 'VSUP*0' 5.570500000000e-05 'VSUP*1' 6.630000000000e-05 'VSUP*1' 6.630500000000e-05 'VSUP*0' 7.370000000000e-05 'VSUP*0' 7.370500000000e-05 'VSUP*0' 8.430000000000e-05 'VSUP*0' 8.430500000000e-05 'VSUP*1' 9.170000000000e-05 'VSUP*1' 9.170500000000e-05 'VSUP*0' 1.023000000000e-04 'VSUP*0' 1.023050000000e-04 'VSUP*1' 1.097000000000e-04 'VSUP*1' 1.097050000000e-04 'VSUP*0' 1.203000000000e-04 'VSUP*0' 1.203050000000e-04 'VSUP*1' 1.277000000000e-04 'VSUP*1' 1.277050000000e-04 'VSUP*0' 1.383000000000e-04 'VSUP*0' 1.383050000000e-04 'VSUP*1' 1.457000000000e-04 'VSUP*1' 1.457050000000e-04 'VSUP*1' 1.563000000000e-04 'VSUP*1' 1.563050000000e-04 'VSUP*0' 1.637000000000e-04 'VSUP*0' 1.637050000000e-04 'VSUP*1' 1.743000000000e-04 'VSUP*1' 1.743050000000e-04 'VSUP*0' 1.817000000000e-04 'VSUP*0' 1.817050000000e-04 'VSUP*1' 1.923000000000e-04 'VSUP*1' 1.923050000000e-04 'VSUP*0' 1.997000000000e-04 'VSUP*0' 1.997050000000e-04 'VSUP*1' 2.103000000000e-04 'VSUP*1' 2.103050000000e-04 'VSUP*0' 2.177000000000e-04 'VSUP*0' 2.177050000000e-04 'VSUP*0' 2.283000000000e-04 'VSUP*0' 2.283050000000e-04 'VSUP*1' 2.357000000000e-04 'VSUP*1' 2.357050000000e-04 'VSUP*0' 2.463000000000e-04 'VSUP*0' 2.463050000000e-04 'VSUP*1' 2.537000000000e-04 'VSUP*1' 2.537050000000e-04 'VSUP*0' 2.643000000000e-04 'VSUP*0' 2.643050000000e-04 'VSUP*1' 2.717000000000e-04 'VSUP*1' 2.717050000000e-04 'VSUP*0' 2.823000000000e-04 'VSUP*0' 2.823050000000e-04 'VSUP*1')"}
C {devices/lab_pin.sym} 1300 3870 0 0 {name=l382 lab=WE}
C {devices/lab_pin.sym} 1300 3930 0 0 {name=l383 lab=0}
T {WE stimulus} 1200 3720 0 0 0.3 0.3 {}
C {devices/gnd.sym} -1100 4050 0 0 {name=g0 lab=0}
T {SIMULATION-ONLY EXTRA WIRE LOADS (MOS intrinsic capacitance is already present)} 2200 3690 0 0 0.34 0.34 {}
C {devices/capa.sym} 2300 3910 0 0 {name=CLOAD_BL0 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 2300 3880 0 0 {name=l388 lab=BL0}
C {devices/lab_pin.sym} 2300 3940 0 0 {name=l389 lab=0}
C {devices/capa.sym} 2600 3910 0 0 {name=CLOAD_BLB0 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 2600 3880 0 0 {name=l391 lab=BLB0}
C {devices/lab_pin.sym} 2600 3940 0 0 {name=l392 lab=0}
C {devices/capa.sym} 2900 3910 0 0 {name=CLOAD_BL1 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 2900 3880 0 0 {name=l394 lab=BL1}
C {devices/lab_pin.sym} 2900 3940 0 0 {name=l395 lab=0}
C {devices/capa.sym} 3200 3910 0 0 {name=CLOAD_BLB1 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 3200 3880 0 0 {name=l397 lab=BLB1}
C {devices/lab_pin.sym} 3200 3940 0 0 {name=l398 lab=0}
C {devices/capa.sym} 3500 3910 0 0 {name=CLOAD_BL2 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 3500 3880 0 0 {name=l400 lab=BL2}
C {devices/lab_pin.sym} 3500 3940 0 0 {name=l401 lab=0}
C {devices/capa.sym} 3800 3910 0 0 {name=CLOAD_BLB2 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 3800 3880 0 0 {name=l403 lab=BLB2}
C {devices/lab_pin.sym} 3800 3940 0 0 {name=l404 lab=0}
C {devices/capa.sym} 4100 3910 0 0 {name=CLOAD_BL3 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 4100 3880 0 0 {name=l406 lab=BL3}
C {devices/lab_pin.sym} 4100 3940 0 0 {name=l407 lab=0}
C {devices/capa.sym} 4400 3910 0 0 {name=CLOAD_BLB3 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 4400 3880 0 0 {name=l409 lab=BLB3}
C {devices/lab_pin.sym} 4400 3940 0 0 {name=l410 lab=0}
C {devices/capa.sym} 4700 3910 0 0 {name=CLOAD_BL4 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 4700 3880 0 0 {name=l412 lab=BL4}
C {devices/lab_pin.sym} 4700 3940 0 0 {name=l413 lab=0}
C {devices/capa.sym} 5000 3910 0 0 {name=CLOAD_BLB4 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 5000 3880 0 0 {name=l415 lab=BLB4}
C {devices/lab_pin.sym} 5000 3940 0 0 {name=l416 lab=0}
C {devices/capa.sym} 5300 3910 0 0 {name=CLOAD_BL5 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 5300 3880 0 0 {name=l418 lab=BL5}
C {devices/lab_pin.sym} 5300 3940 0 0 {name=l419 lab=0}
C {devices/capa.sym} 5600 3910 0 0 {name=CLOAD_BLB5 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 5600 3880 0 0 {name=l421 lab=BLB5}
C {devices/lab_pin.sym} 5600 3940 0 0 {name=l422 lab=0}
C {devices/capa.sym} 5900 3910 0 0 {name=CLOAD_BL6 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 5900 3880 0 0 {name=l424 lab=BL6}
C {devices/lab_pin.sym} 5900 3940 0 0 {name=l425 lab=0}
C {devices/capa.sym} 6200 3910 0 0 {name=CLOAD_BLB6 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 6200 3880 0 0 {name=l427 lab=BLB6}
C {devices/lab_pin.sym} 6200 3940 0 0 {name=l428 lab=0}
C {devices/capa.sym} 6500 3910 0 0 {name=CLOAD_BL7 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 6500 3880 0 0 {name=l430 lab=BL7}
C {devices/lab_pin.sym} 6500 3940 0 0 {name=l431 lab=0}
C {devices/capa.sym} 6800 3910 0 0 {name=CLOAD_BLB7 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 6800 3880 0 0 {name=l433 lab=BLB7}
C {devices/lab_pin.sym} 6800 3940 0 0 {name=l434 lab=0}
C {devices/capa.sym} 2300 4140 0 0 {name=CLOAD_BL8 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 2300 4110 0 0 {name=l436 lab=BL8}
C {devices/lab_pin.sym} 2300 4170 0 0 {name=l437 lab=0}
C {devices/capa.sym} 2600 4140 0 0 {name=CLOAD_BLB8 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 2600 4110 0 0 {name=l439 lab=BLB8}
C {devices/lab_pin.sym} 2600 4170 0 0 {name=l440 lab=0}
C {devices/capa.sym} 2900 4140 0 0 {name=CLOAD_BL9 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 2900 4110 0 0 {name=l442 lab=BL9}
C {devices/lab_pin.sym} 2900 4170 0 0 {name=l443 lab=0}
C {devices/capa.sym} 3200 4140 0 0 {name=CLOAD_BLB9 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 3200 4110 0 0 {name=l445 lab=BLB9}
C {devices/lab_pin.sym} 3200 4170 0 0 {name=l446 lab=0}
C {devices/capa.sym} 3500 4140 0 0 {name=CLOAD_BL10 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 3500 4110 0 0 {name=l448 lab=BL10}
C {devices/lab_pin.sym} 3500 4170 0 0 {name=l449 lab=0}
C {devices/capa.sym} 3800 4140 0 0 {name=CLOAD_BLB10 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 3800 4110 0 0 {name=l451 lab=BLB10}
C {devices/lab_pin.sym} 3800 4170 0 0 {name=l452 lab=0}
C {devices/capa.sym} 4100 4140 0 0 {name=CLOAD_BL11 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 4100 4110 0 0 {name=l454 lab=BL11}
C {devices/lab_pin.sym} 4100 4170 0 0 {name=l455 lab=0}
C {devices/capa.sym} 4400 4140 0 0 {name=CLOAD_BLB11 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 4400 4110 0 0 {name=l457 lab=BLB11}
C {devices/lab_pin.sym} 4400 4170 0 0 {name=l458 lab=0}
C {devices/capa.sym} 4700 4140 0 0 {name=CLOAD_BL12 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 4700 4110 0 0 {name=l460 lab=BL12}
C {devices/lab_pin.sym} 4700 4170 0 0 {name=l461 lab=0}
C {devices/capa.sym} 5000 4140 0 0 {name=CLOAD_BLB12 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 5000 4110 0 0 {name=l463 lab=BLB12}
C {devices/lab_pin.sym} 5000 4170 0 0 {name=l464 lab=0}
C {devices/capa.sym} 5300 4140 0 0 {name=CLOAD_BL13 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 5300 4110 0 0 {name=l466 lab=BL13}
C {devices/lab_pin.sym} 5300 4170 0 0 {name=l467 lab=0}
C {devices/capa.sym} 5600 4140 0 0 {name=CLOAD_BLB13 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 5600 4110 0 0 {name=l469 lab=BLB13}
C {devices/lab_pin.sym} 5600 4170 0 0 {name=l470 lab=0}
C {devices/capa.sym} 5900 4140 0 0 {name=CLOAD_BL14 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 5900 4110 0 0 {name=l472 lab=BL14}
C {devices/lab_pin.sym} 5900 4170 0 0 {name=l473 lab=0}
C {devices/capa.sym} 6200 4140 0 0 {name=CLOAD_BLB14 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 6200 4110 0 0 {name=l475 lab=BLB14}
C {devices/lab_pin.sym} 6200 4170 0 0 {name=l476 lab=0}
C {devices/capa.sym} 6500 4140 0 0 {name=CLOAD_BL15 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 6500 4110 0 0 {name=l478 lab=BL15}
C {devices/lab_pin.sym} 6500 4170 0 0 {name=l479 lab=0}
C {devices/capa.sym} 6800 4140 0 0 {name=CLOAD_BLB15 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 6800 4110 0 0 {name=l481 lab=BLB15}
C {devices/lab_pin.sym} 6800 4170 0 0 {name=l482 lab=0}
C {devices/capa.sym} 2300 4370 0 0 {name=CLOAD_BL16 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 2300 4340 0 0 {name=l484 lab=BL16}
C {devices/lab_pin.sym} 2300 4400 0 0 {name=l485 lab=0}
C {devices/capa.sym} 2600 4370 0 0 {name=CLOAD_BLB16 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 2600 4340 0 0 {name=l487 lab=BLB16}
C {devices/lab_pin.sym} 2600 4400 0 0 {name=l488 lab=0}
C {devices/capa.sym} 2900 4370 0 0 {name=CLOAD_BL17 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 2900 4340 0 0 {name=l490 lab=BL17}
C {devices/lab_pin.sym} 2900 4400 0 0 {name=l491 lab=0}
C {devices/capa.sym} 3200 4370 0 0 {name=CLOAD_BLB17 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 3200 4340 0 0 {name=l493 lab=BLB17}
C {devices/lab_pin.sym} 3200 4400 0 0 {name=l494 lab=0}
C {devices/capa.sym} 3500 4370 0 0 {name=CLOAD_BL18 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 3500 4340 0 0 {name=l496 lab=BL18}
C {devices/lab_pin.sym} 3500 4400 0 0 {name=l497 lab=0}
C {devices/capa.sym} 3800 4370 0 0 {name=CLOAD_BLB18 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 3800 4340 0 0 {name=l499 lab=BLB18}
C {devices/lab_pin.sym} 3800 4400 0 0 {name=l500 lab=0}
C {devices/capa.sym} 4100 4370 0 0 {name=CLOAD_BL19 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 4100 4340 0 0 {name=l502 lab=BL19}
C {devices/lab_pin.sym} 4100 4400 0 0 {name=l503 lab=0}
C {devices/capa.sym} 4400 4370 0 0 {name=CLOAD_BLB19 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 4400 4340 0 0 {name=l505 lab=BLB19}
C {devices/lab_pin.sym} 4400 4400 0 0 {name=l506 lab=0}
C {devices/capa.sym} 4700 4370 0 0 {name=CLOAD_BL20 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 4700 4340 0 0 {name=l508 lab=BL20}
C {devices/lab_pin.sym} 4700 4400 0 0 {name=l509 lab=0}
C {devices/capa.sym} 5000 4370 0 0 {name=CLOAD_BLB20 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 5000 4340 0 0 {name=l511 lab=BLB20}
C {devices/lab_pin.sym} 5000 4400 0 0 {name=l512 lab=0}
C {devices/capa.sym} 5300 4370 0 0 {name=CLOAD_BL21 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 5300 4340 0 0 {name=l514 lab=BL21}
C {devices/lab_pin.sym} 5300 4400 0 0 {name=l515 lab=0}
C {devices/capa.sym} 5600 4370 0 0 {name=CLOAD_BLB21 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 5600 4340 0 0 {name=l517 lab=BLB21}
C {devices/lab_pin.sym} 5600 4400 0 0 {name=l518 lab=0}
C {devices/capa.sym} 5900 4370 0 0 {name=CLOAD_BL22 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 5900 4340 0 0 {name=l520 lab=BL22}
C {devices/lab_pin.sym} 5900 4400 0 0 {name=l521 lab=0}
C {devices/capa.sym} 6200 4370 0 0 {name=CLOAD_BLB22 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 6200 4340 0 0 {name=l523 lab=BLB22}
C {devices/lab_pin.sym} 6200 4400 0 0 {name=l524 lab=0}
C {devices/capa.sym} 6500 4370 0 0 {name=CLOAD_BL23 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 6500 4340 0 0 {name=l526 lab=BL23}
C {devices/lab_pin.sym} 6500 4400 0 0 {name=l527 lab=0}
C {devices/capa.sym} 6800 4370 0 0 {name=CLOAD_BLB23 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 6800 4340 0 0 {name=l529 lab=BLB23}
C {devices/lab_pin.sym} 6800 4400 0 0 {name=l530 lab=0}
C {devices/capa.sym} 2300 4600 0 0 {name=CLOAD_BL24 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 2300 4570 0 0 {name=l532 lab=BL24}
C {devices/lab_pin.sym} 2300 4630 0 0 {name=l533 lab=0}
C {devices/capa.sym} 2600 4600 0 0 {name=CLOAD_BLB24 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 2600 4570 0 0 {name=l535 lab=BLB24}
C {devices/lab_pin.sym} 2600 4630 0 0 {name=l536 lab=0}
C {devices/capa.sym} 2900 4600 0 0 {name=CLOAD_BL25 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 2900 4570 0 0 {name=l538 lab=BL25}
C {devices/lab_pin.sym} 2900 4630 0 0 {name=l539 lab=0}
C {devices/capa.sym} 3200 4600 0 0 {name=CLOAD_BLB25 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 3200 4570 0 0 {name=l541 lab=BLB25}
C {devices/lab_pin.sym} 3200 4630 0 0 {name=l542 lab=0}
C {devices/capa.sym} 3500 4600 0 0 {name=CLOAD_BL26 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 3500 4570 0 0 {name=l544 lab=BL26}
C {devices/lab_pin.sym} 3500 4630 0 0 {name=l545 lab=0}
C {devices/capa.sym} 3800 4600 0 0 {name=CLOAD_BLB26 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 3800 4570 0 0 {name=l547 lab=BLB26}
C {devices/lab_pin.sym} 3800 4630 0 0 {name=l548 lab=0}
C {devices/capa.sym} 4100 4600 0 0 {name=CLOAD_BL27 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 4100 4570 0 0 {name=l550 lab=BL27}
C {devices/lab_pin.sym} 4100 4630 0 0 {name=l551 lab=0}
C {devices/capa.sym} 4400 4600 0 0 {name=CLOAD_BLB27 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 4400 4570 0 0 {name=l553 lab=BLB27}
C {devices/lab_pin.sym} 4400 4630 0 0 {name=l554 lab=0}
C {devices/capa.sym} 4700 4600 0 0 {name=CLOAD_BL28 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 4700 4570 0 0 {name=l556 lab=BL28}
C {devices/lab_pin.sym} 4700 4630 0 0 {name=l557 lab=0}
C {devices/capa.sym} 5000 4600 0 0 {name=CLOAD_BLB28 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 5000 4570 0 0 {name=l559 lab=BLB28}
C {devices/lab_pin.sym} 5000 4630 0 0 {name=l560 lab=0}
C {devices/capa.sym} 5300 4600 0 0 {name=CLOAD_BL29 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 5300 4570 0 0 {name=l562 lab=BL29}
C {devices/lab_pin.sym} 5300 4630 0 0 {name=l563 lab=0}
C {devices/capa.sym} 5600 4600 0 0 {name=CLOAD_BLB29 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 5600 4570 0 0 {name=l565 lab=BLB29}
C {devices/lab_pin.sym} 5600 4630 0 0 {name=l566 lab=0}
C {devices/capa.sym} 5900 4600 0 0 {name=CLOAD_BL30 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 5900 4570 0 0 {name=l568 lab=BL30}
C {devices/lab_pin.sym} 5900 4630 0 0 {name=l569 lab=0}
C {devices/capa.sym} 6200 4600 0 0 {name=CLOAD_BLB30 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 6200 4570 0 0 {name=l571 lab=BLB30}
C {devices/lab_pin.sym} 6200 4630 0 0 {name=l572 lab=0}
C {devices/capa.sym} 6500 4600 0 0 {name=CLOAD_BL31 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 6500 4570 0 0 {name=l574 lab=BL31}
C {devices/lab_pin.sym} 6500 4630 0 0 {name=l575 lab=0}
C {devices/capa.sym} 6800 4600 0 0 {name=CLOAD_BLB31 value="'CBLWIRE'"}
C {devices/lab_pin.sym} 6800 4570 0 0 {name=l577 lab=BLB31}
C {devices/lab_pin.sym} 6800 4630 0 0 {name=l578 lab=0}
C {devices/capa.sym} 2300 4830 0 0 {name=CLOAD_WL0 value="'CWLWIRE'"}
C {devices/lab_pin.sym} 2300 4800 0 0 {name=l580 lab=WL0}
C {devices/lab_pin.sym} 2300 4860 0 0 {name=l581 lab=0}
C {devices/capa.sym} 2600 4830 0 0 {name=CLOAD_WL1 value="'CWLWIRE'"}
C {devices/lab_pin.sym} 2600 4800 0 0 {name=l583 lab=WL1}
C {devices/lab_pin.sym} 2600 4860 0 0 {name=l584 lab=0}
C {devices/capa.sym} 2900 4830 0 0 {name=CLOAD_WL2 value="'CWLWIRE'"}
C {devices/lab_pin.sym} 2900 4800 0 0 {name=l586 lab=WL2}
C {devices/lab_pin.sym} 2900 4860 0 0 {name=l587 lab=0}
C {devices/capa.sym} 3200 4830 0 0 {name=CLOAD_WL3 value="'CWLWIRE'"}
C {devices/lab_pin.sym} 3200 4800 0 0 {name=l589 lab=WL3}
C {devices/lab_pin.sym} 3200 4860 0 0 {name=l590 lab=0}
C {devices/capa.sym} 3500 4830 0 0 {name=CLOAD_WL4 value="'CWLWIRE'"}
C {devices/lab_pin.sym} 3500 4800 0 0 {name=l592 lab=WL4}
C {devices/lab_pin.sym} 3500 4860 0 0 {name=l593 lab=0}
C {devices/capa.sym} 3800 4830 0 0 {name=CLOAD_WL5 value="'CWLWIRE'"}
C {devices/lab_pin.sym} 3800 4800 0 0 {name=l595 lab=WL5}
C {devices/lab_pin.sym} 3800 4860 0 0 {name=l596 lab=0}
C {devices/capa.sym} 4100 4830 0 0 {name=CLOAD_WL6 value="'CWLWIRE'"}
C {devices/lab_pin.sym} 4100 4800 0 0 {name=l598 lab=WL6}
C {devices/lab_pin.sym} 4100 4860 0 0 {name=l599 lab=0}
C {devices/capa.sym} 4400 4830 0 0 {name=CLOAD_WL7 value="'CWLWIRE'"}
C {devices/lab_pin.sym} 4400 4800 0 0 {name=l601 lab=WL7}
C {devices/lab_pin.sym} 4400 4860 0 0 {name=l602 lab=0}
C {devices/capa.sym} 4700 4830 0 0 {name=CLOAD_WL8 value="'CWLWIRE'"}
C {devices/lab_pin.sym} 4700 4800 0 0 {name=l604 lab=WL8}
C {devices/lab_pin.sym} 4700 4860 0 0 {name=l605 lab=0}
C {devices/capa.sym} 5000 4830 0 0 {name=CLOAD_WL9 value="'CWLWIRE'"}
C {devices/lab_pin.sym} 5000 4800 0 0 {name=l607 lab=WL9}
C {devices/lab_pin.sym} 5000 4860 0 0 {name=l608 lab=0}
C {devices/capa.sym} 5300 4830 0 0 {name=CLOAD_WL10 value="'CWLWIRE'"}
C {devices/lab_pin.sym} 5300 4800 0 0 {name=l610 lab=WL10}
C {devices/lab_pin.sym} 5300 4860 0 0 {name=l611 lab=0}
C {devices/capa.sym} 5600 4830 0 0 {name=CLOAD_WL11 value="'CWLWIRE'"}
C {devices/lab_pin.sym} 5600 4800 0 0 {name=l613 lab=WL11}
C {devices/lab_pin.sym} 5600 4860 0 0 {name=l614 lab=0}
C {devices/capa.sym} 5900 4830 0 0 {name=CLOAD_WL12 value="'CWLWIRE'"}
C {devices/lab_pin.sym} 5900 4800 0 0 {name=l616 lab=WL12}
C {devices/lab_pin.sym} 5900 4860 0 0 {name=l617 lab=0}
C {devices/capa.sym} 6200 4830 0 0 {name=CLOAD_WL13 value="'CWLWIRE'"}
C {devices/lab_pin.sym} 6200 4800 0 0 {name=l619 lab=WL13}
C {devices/lab_pin.sym} 6200 4860 0 0 {name=l620 lab=0}
C {devices/capa.sym} 6500 4830 0 0 {name=CLOAD_WL14 value="'CWLWIRE'"}
C {devices/lab_pin.sym} 6500 4800 0 0 {name=l622 lab=WL14}
C {devices/lab_pin.sym} 6500 4860 0 0 {name=l623 lab=0}
C {devices/capa.sym} 6800 4830 0 0 {name=CLOAD_WL15 value="'CWLWIRE'"}
C {devices/lab_pin.sym} 6800 4800 0 0 {name=l625 lab=WL15}
C {devices/lab_pin.sym} 6800 4860 0 0 {name=l626 lab=0}
C {devices/capa.sym} 2300 5060 0 0 {name=CLOAD_Y value="'CYWIRE'"}
C {devices/lab_pin.sym} 2300 5030 0 0 {name=l628 lab=Y}
C {devices/lab_pin.sym} 2300 5090 0 0 {name=l629 lab=0}
C {devices/capa.sym} 2600 5060 0 0 {name=CLOAD_YB value="'CYWIRE'"}
C {devices/lab_pin.sym} 2600 5030 0 0 {name=l631 lab=YB}
C {devices/lab_pin.sym} 2600 5090 0 0 {name=l632 lab=0}
C {devices/capa.sym} 2900 5060 0 0 {name=CLOAD_SDO value="'CSDO'"}
C {devices/lab_pin.sym} 2900 5030 0 0 {name=l634 lab=SDO}
C {devices/lab_pin.sym} 2900 5090 0 0 {name=l635 lab=0}
C {devices/code.sym} -1100 4330 0 0 {name=MODELS only_toplevel=true format="tcleval( @value )" value=".include $::LIB/ip62_models"}
C {devices/code.sym} -550 4330 0 0 {name=SIMULATION only_toplevel=true value=".param VSUP=5 CBLWIRE=70f CWLWIRE=400f CYWIRE=180f CSDO=10p
.temp 27
.control
set num_threads=1
save v(VDD) v(CLK) v(RESET) v(SDI) v(WE) v(SDO) v(PREB) v(SAE) v(WL_EN) v(WRITE_EN) v(DIN) v(PD_Y) v(PD_YB) v(Y) v(YB) v(SOUT) v(SOUTB) v(RA0) v(RA1) v(RA2) v(RA3) v(CA0) v(CA1) v(CA2) v(CA3) v(CA4) v(WL0) v(WL1) v(WL2) v(WL3) v(WL4) v(WL5) v(WL6) v(WL7) v(WL8) v(WL9) v(WL10) v(WL11) v(WL12) v(WL13) v(WL14) v(WL15) v(COL0) v(COL1) v(COL2) v(COL3) v(COL4) v(COL5) v(COL6) v(COL7) v(COL8) v(COL9) v(COL10) v(COL11) v(COL12) v(COL13) v(COL14) v(COL15) v(COL16) v(COL17) v(COL18) v(COL19) v(COL20) v(COL21) v(COL22) v(COL23) v(COL24) v(COL25) v(COL26) v(COL27) v(COL28) v(COL29) v(COL30) v(COL31) v(BL0) v(BL1) v(BL2) v(BL3) v(BL4) v(BL5) v(BL6) v(BL7) v(BL8) v(BL9) v(BL10) v(BL11) v(BL12) v(BL13) v(BL14) v(BL15) v(BL16) v(BL17) v(BL18) v(BL19) v(BL20) v(BL21) v(BL22) v(BL23) v(BL24) v(BL25) v(BL26) v(BL27) v(BL28) v(BL29) v(BL30) v(BL31) v(BLB0) v(BLB1) v(BLB2) v(BLB3) v(BLB4) v(BLB5) v(BLB6) v(BLB7) v(BLB8) v(BLB9) v(BLB10) v(BLB11) v(BLB12) v(BLB13) v(BLB14) v(BLB15) v(BLB16) v(BLB17) v(BLB18) v(BLB19) v(BLB20) v(BLB21) v(BLB22) v(BLB23) v(BLB24) v(BLB25) v(BLB26) v(BLB27) v(BLB28) v(BLB29) v(BLB30) v(BLB31) v(xctrl.xphase.C0) v(xctrl.xphase.C1) v(xctrl.xphase.C2) v(xctrl.xphase.C3) v(xctrl.xphase.C4) v(xctrl.CKI) v(xctrl.RSTI) v(xctrl.xcontrol.W) v(xarray.xr0c0.Q) v(xarray.xr0c0.QB) v(xarray.xr0c31.Q) v(xarray.xr0c31.QB) v(xarray.xr15c0.Q) v(xarray.xr15c0.QB) v(xarray.xr15c31.Q) v(xarray.xr15c31.QB)
tran 5n 2.900000000000e-04 0 20n
let failures=0
meas tran check_0_0 find v(xarray.xr0c0.Q) at=1.980000000000e-05
if check_0_0 > 0.1 * v(VDD)[0]
 let failures=failures+1
end
meas tran check_0_1 find v(SDO) at=1.980000000000e-05
if check_0_1 > 0.1 * v(VDD)[0]
 let failures=failures+1
end
meas tran check_1_0 find v(xarray.xr0c31.Q) at=3.780000000000e-05
if check_1_0 < 0.9 * v(VDD)[0]
 let failures=failures+1
end
meas tran check_1_1 find v(SDO) at=3.780000000000e-05
if check_1_1 > 0.1 * v(VDD)[0]
 let failures=failures+1
end
meas tran check_2_0 find v(xarray.xr15c0.Q) at=5.580000000000e-05
if check_2_0 < 0.9 * v(VDD)[0]
 let failures=failures+1
end
meas tran check_2_1 find v(SDO) at=5.580000000000e-05
if check_2_1 > 0.1 * v(VDD)[0]
 let failures=failures+1
end
meas tran check_3_0 find v(xarray.xr15c31.Q) at=7.380000000000e-05
if check_3_0 > 0.1 * v(VDD)[0]
 let failures=failures+1
end
meas tran check_3_1 find v(SDO) at=7.380000000000e-05
if check_3_1 > 0.1 * v(VDD)[0]
 let failures=failures+1
end
meas tran check_4_0 find v(xarray.xr0c0.Q) at=9.180000000000e-05
if check_4_0 > 0.1 * v(VDD)[0]
 let failures=failures+1
end
meas tran check_4_1 find v(SDO) at=9.180000000000e-05
if check_4_1 > 0.1 * v(VDD)[0]
 let failures=failures+1
end
meas tran check_5_0 find v(xarray.xr0c31.Q) at=1.098000000000e-04
if check_5_0 < 0.9 * v(VDD)[0]
 let failures=failures+1
end
meas tran check_5_1 find v(SDO) at=1.098000000000e-04
if check_5_1 < 0.9 * v(VDD)[0]
 let failures=failures+1
end
meas tran check_6_0 find v(xarray.xr15c0.Q) at=1.278000000000e-04
if check_6_0 < 0.9 * v(VDD)[0]
 let failures=failures+1
end
meas tran check_6_1 find v(SDO) at=1.278000000000e-04
if check_6_1 < 0.9 * v(VDD)[0]
 let failures=failures+1
end
meas tran check_7_0 find v(xarray.xr15c31.Q) at=1.458000000000e-04
if check_7_0 > 0.1 * v(VDD)[0]
 let failures=failures+1
end
meas tran check_7_1 find v(SDO) at=1.458000000000e-04
if check_7_1 > 0.1 * v(VDD)[0]
 let failures=failures+1
end
meas tran check_8_0 find v(xarray.xr0c0.Q) at=1.638000000000e-04
if check_8_0 < 0.9 * v(VDD)[0]
 let failures=failures+1
end
meas tran check_8_1 find v(SDO) at=1.638000000000e-04
if check_8_1 > 0.1 * v(VDD)[0]
 let failures=failures+1
end
meas tran check_9_0 find v(xarray.xr0c31.Q) at=1.818000000000e-04
if check_9_0 > 0.1 * v(VDD)[0]
 let failures=failures+1
end
meas tran check_9_1 find v(SDO) at=1.818000000000e-04
if check_9_1 > 0.1 * v(VDD)[0]
 let failures=failures+1
end
meas tran check_10_0 find v(xarray.xr15c0.Q) at=1.998000000000e-04
if check_10_0 > 0.1 * v(VDD)[0]
 let failures=failures+1
end
meas tran check_10_1 find v(SDO) at=1.998000000000e-04
if check_10_1 > 0.1 * v(VDD)[0]
 let failures=failures+1
end
meas tran check_11_0 find v(xarray.xr15c31.Q) at=2.178000000000e-04
if check_11_0 < 0.9 * v(VDD)[0]
 let failures=failures+1
end
meas tran check_11_1 find v(SDO) at=2.178000000000e-04
if check_11_1 > 0.1 * v(VDD)[0]
 let failures=failures+1
end
meas tran check_12_0 find v(xarray.xr0c0.Q) at=2.358000000000e-04
if check_12_0 < 0.9 * v(VDD)[0]
 let failures=failures+1
end
meas tran check_12_1 find v(SDO) at=2.358000000000e-04
if check_12_1 < 0.9 * v(VDD)[0]
 let failures=failures+1
end
meas tran check_13_0 find v(xarray.xr0c31.Q) at=2.538000000000e-04
if check_13_0 > 0.1 * v(VDD)[0]
 let failures=failures+1
end
meas tran check_13_1 find v(SDO) at=2.538000000000e-04
if check_13_1 > 0.1 * v(VDD)[0]
 let failures=failures+1
end
meas tran check_14_0 find v(xarray.xr15c0.Q) at=2.718000000000e-04
if check_14_0 > 0.1 * v(VDD)[0]
 let failures=failures+1
end
meas tran check_14_1 find v(SDO) at=2.718000000000e-04
if check_14_1 > 0.1 * v(VDD)[0]
 let failures=failures+1
end
meas tran check_15_0 find v(xarray.xr15c31.Q) at=2.898000000000e-04
if check_15_0 < 0.9 * v(VDD)[0]
 let failures=failures+1
end
meas tran check_15_1 find v(SDO) at=2.898000000000e-04
if check_15_1 < 0.9 * v(VDD)[0]
 let failures=failures+1
end
if failures=0
echo 'PASS: 16 accesses; stored cell and SDO checks'
else
echo 'FAIL: inspect failures and waveforms'
print failures
end
write sram512_tb.raw
plot v(SDO) v(SOUT) v(SOUTB) title '512 bit: read result is captured at E6'
plot v(Y) v(YB) v(SAE) title 'Shared lines and sense enable'
plot v(WL0) v(WL15) v(PREB) v(WRITE_EN) title 'Registered access sequence'
.endc"}
C {devices/netlist_options.sym} 0 4330 0 0 {name=TB_OPTIONS lvs_netlist=false top_is_subckt=false spiceprefix=true hiersep=. }
T {2 us: W row 0, column 0 = 0} -1100 4570 0 0 0.28 0.28 {}
T {20 us: W row 0, column 31 = 1} -1100 4630 0 0 0.28 0.28 {}
T {38 us: W row 15, column 0 = 1} -1100 4690 0 0 0.28 0.28 {}
T {56 us: W row 15, column 31 = 0} -1100 4750 0 0 0.28 0.28 {}
T {74 us: R row 0, column 0 = 0} -1100 4810 0 0 0.28 0.28 {}
T {92 us: R row 0, column 31 = 1} -1100 4870 0 0 0.28 0.28 {}
T {110 us: R row 15, column 0 = 1} -1100 4930 0 0 0.28 0.28 {}
T {128 us: R row 15, column 31 = 0} -1100 4990 0 0 0.28 0.28 {}
T {146 us: W row 0, column 0 = 1} -1100 5050 0 0 0.28 0.28 {}
T {164 us: W row 0, column 31 = 0} -1100 5110 0 0 0.28 0.28 {}
T {182 us: W row 15, column 0 = 0} -1100 5170 0 0 0.28 0.28 {}
T {200 us: W row 15, column 31 = 1} -1100 5230 0 0 0.28 0.28 {}
T {218 us: R row 0, column 0 = 1} -1100 5290 0 0 0.28 0.28 {}
T {236 us: R row 0, column 31 = 0} -1100 5350 0 0 0.28 0.28 {}
T {254 us: R row 15, column 0 = 0} -1100 5410 0 0 0.28 0.28 {}
T {272 us: R row 15, column 31 = 1} -1100 5470 0 0 0.28 0.28 {}
C {devices/lab_pin.sym} 3800 -720 0 0 {name=l655 lab=VDD}
C {devices/lab_pin.sym} 4200 -720 0 0 {name=l656 lab=0}
C {devices/lab_pin.sym} 140 -80 0 0 {name=l657 lab=RA0}
C {devices/lab_pin.sym} 140 -40 0 0 {name=l658 lab=RA1}
C {devices/lab_pin.sym} 140 0 0 0 {name=l659 lab=RA2}
C {devices/lab_pin.sym} 140 40 0 0 {name=l660 lab=RA3}
C {devices/lab_pin.sym} 140 80 0 0 {name=l661 lab=WL_EN}
C {devices/lab_pin.sym} 300 -400 0 0 {name=l662 lab=VDD}
C {devices/lab_pin.sym} 300 400 0 0 {name=l663 lab=0}
C {devices/lab_pin.sym} 800 1250 0 0 {name=l664 lab=PREB}
C {devices/lab_pin.sym} 900 1140 0 0 {name=l665 lab=VDD}
C {devices/lab_pin.sym} 1000 1350 0 0 {name=l666 lab=0}
C {devices/lab_pin.sym} 1000 1250 0 0 {name=l667 lab=PREB}
C {devices/lab_pin.sym} 1100 1140 0 0 {name=l668 lab=VDD}
C {devices/lab_pin.sym} 1200 1350 0 0 {name=l669 lab=0}
C {devices/lab_pin.sym} 1200 1250 0 0 {name=l670 lab=PREB}
C {devices/lab_pin.sym} 1300 1140 0 0 {name=l671 lab=VDD}
C {devices/lab_pin.sym} 1400 1350 0 0 {name=l672 lab=0}
C {devices/lab_pin.sym} 1400 1250 0 0 {name=l673 lab=PREB}
C {devices/lab_pin.sym} 1500 1140 0 0 {name=l674 lab=VDD}
C {devices/lab_pin.sym} 1600 1350 0 0 {name=l675 lab=0}
C {devices/lab_pin.sym} 1600 1250 0 0 {name=l676 lab=PREB}
C {devices/lab_pin.sym} 1700 1140 0 0 {name=l677 lab=VDD}
C {devices/lab_pin.sym} 1800 1350 0 0 {name=l678 lab=0}
C {devices/lab_pin.sym} 1800 1250 0 0 {name=l679 lab=PREB}
C {devices/lab_pin.sym} 1900 1140 0 0 {name=l680 lab=VDD}
C {devices/lab_pin.sym} 2000 1350 0 0 {name=l681 lab=0}
C {devices/lab_pin.sym} 2000 1250 0 0 {name=l682 lab=PREB}
C {devices/lab_pin.sym} 2100 1140 0 0 {name=l683 lab=VDD}
C {devices/lab_pin.sym} 2200 1350 0 0 {name=l684 lab=0}
C {devices/lab_pin.sym} 2200 1250 0 0 {name=l685 lab=PREB}
C {devices/lab_pin.sym} 2300 1140 0 0 {name=l686 lab=VDD}
C {devices/lab_pin.sym} 2400 1350 0 0 {name=l687 lab=0}
C {devices/lab_pin.sym} 2400 1250 0 0 {name=l688 lab=PREB}
C {devices/lab_pin.sym} 2500 1140 0 0 {name=l689 lab=VDD}
C {devices/lab_pin.sym} 2600 1350 0 0 {name=l690 lab=0}
C {devices/lab_pin.sym} 2600 1250 0 0 {name=l691 lab=PREB}
C {devices/lab_pin.sym} 2700 1140 0 0 {name=l692 lab=VDD}
C {devices/lab_pin.sym} 2800 1350 0 0 {name=l693 lab=0}
C {devices/lab_pin.sym} 2800 1250 0 0 {name=l694 lab=PREB}
C {devices/lab_pin.sym} 2900 1140 0 0 {name=l695 lab=VDD}
C {devices/lab_pin.sym} 3000 1350 0 0 {name=l696 lab=0}
C {devices/lab_pin.sym} 3000 1250 0 0 {name=l697 lab=PREB}
C {devices/lab_pin.sym} 3100 1140 0 0 {name=l698 lab=VDD}
C {devices/lab_pin.sym} 3200 1350 0 0 {name=l699 lab=0}
C {devices/lab_pin.sym} 3200 1250 0 0 {name=l700 lab=PREB}
C {devices/lab_pin.sym} 3300 1140 0 0 {name=l701 lab=VDD}
C {devices/lab_pin.sym} 3400 1350 0 0 {name=l702 lab=0}
C {devices/lab_pin.sym} 3400 1250 0 0 {name=l703 lab=PREB}
C {devices/lab_pin.sym} 3500 1140 0 0 {name=l704 lab=VDD}
C {devices/lab_pin.sym} 3600 1350 0 0 {name=l705 lab=0}
C {devices/lab_pin.sym} 3600 1250 0 0 {name=l706 lab=PREB}
C {devices/lab_pin.sym} 3700 1140 0 0 {name=l707 lab=VDD}
C {devices/lab_pin.sym} 3800 1350 0 0 {name=l708 lab=0}
C {devices/lab_pin.sym} 3800 1250 0 0 {name=l709 lab=PREB}
C {devices/lab_pin.sym} 3900 1140 0 0 {name=l710 lab=VDD}
C {devices/lab_pin.sym} 4000 1350 0 0 {name=l711 lab=0}
C {devices/lab_pin.sym} 4000 1250 0 0 {name=l712 lab=PREB}
C {devices/lab_pin.sym} 4100 1140 0 0 {name=l713 lab=VDD}
C {devices/lab_pin.sym} 4200 1350 0 0 {name=l714 lab=0}
C {devices/lab_pin.sym} 4200 1250 0 0 {name=l715 lab=PREB}
C {devices/lab_pin.sym} 4300 1140 0 0 {name=l716 lab=VDD}
C {devices/lab_pin.sym} 4400 1350 0 0 {name=l717 lab=0}
C {devices/lab_pin.sym} 4400 1250 0 0 {name=l718 lab=PREB}
C {devices/lab_pin.sym} 4500 1140 0 0 {name=l719 lab=VDD}
C {devices/lab_pin.sym} 4600 1350 0 0 {name=l720 lab=0}
C {devices/lab_pin.sym} 4600 1250 0 0 {name=l721 lab=PREB}
C {devices/lab_pin.sym} 4700 1140 0 0 {name=l722 lab=VDD}
C {devices/lab_pin.sym} 4800 1350 0 0 {name=l723 lab=0}
C {devices/lab_pin.sym} 4800 1250 0 0 {name=l724 lab=PREB}
C {devices/lab_pin.sym} 4900 1140 0 0 {name=l725 lab=VDD}
C {devices/lab_pin.sym} 5000 1350 0 0 {name=l726 lab=0}
C {devices/lab_pin.sym} 5000 1250 0 0 {name=l727 lab=PREB}
C {devices/lab_pin.sym} 5100 1140 0 0 {name=l728 lab=VDD}
C {devices/lab_pin.sym} 5200 1350 0 0 {name=l729 lab=0}
C {devices/lab_pin.sym} 5200 1250 0 0 {name=l730 lab=PREB}
C {devices/lab_pin.sym} 5300 1140 0 0 {name=l731 lab=VDD}
C {devices/lab_pin.sym} 5400 1350 0 0 {name=l732 lab=0}
C {devices/lab_pin.sym} 5400 1250 0 0 {name=l733 lab=PREB}
C {devices/lab_pin.sym} 5500 1140 0 0 {name=l734 lab=VDD}
C {devices/lab_pin.sym} 5600 1350 0 0 {name=l735 lab=0}
C {devices/lab_pin.sym} 5600 1250 0 0 {name=l736 lab=PREB}
C {devices/lab_pin.sym} 5700 1140 0 0 {name=l737 lab=VDD}
C {devices/lab_pin.sym} 5800 1350 0 0 {name=l738 lab=0}
C {devices/lab_pin.sym} 5800 1250 0 0 {name=l739 lab=PREB}
C {devices/lab_pin.sym} 5900 1140 0 0 {name=l740 lab=VDD}
C {devices/lab_pin.sym} 6000 1350 0 0 {name=l741 lab=0}
C {devices/lab_pin.sym} 6000 1250 0 0 {name=l742 lab=PREB}
C {devices/lab_pin.sym} 6100 1140 0 0 {name=l743 lab=VDD}
C {devices/lab_pin.sym} 6200 1350 0 0 {name=l744 lab=0}
C {devices/lab_pin.sym} 6200 1250 0 0 {name=l745 lab=PREB}
C {devices/lab_pin.sym} 6300 1140 0 0 {name=l746 lab=VDD}
C {devices/lab_pin.sym} 6400 1350 0 0 {name=l747 lab=0}
C {devices/lab_pin.sym} 6400 1250 0 0 {name=l748 lab=PREB}
C {devices/lab_pin.sym} 6500 1140 0 0 {name=l749 lab=VDD}
C {devices/lab_pin.sym} 6600 1350 0 0 {name=l750 lab=0}
C {devices/lab_pin.sym} 6600 1250 0 0 {name=l751 lab=PREB}
C {devices/lab_pin.sym} 6700 1140 0 0 {name=l752 lab=VDD}
C {devices/lab_pin.sym} 6800 1350 0 0 {name=l753 lab=0}
C {devices/lab_pin.sym} 6800 1250 0 0 {name=l754 lab=PREB}
C {devices/lab_pin.sym} 6900 1140 0 0 {name=l755 lab=VDD}
C {devices/lab_pin.sym} 7000 1350 0 0 {name=l756 lab=0}
C {devices/lab_pin.sym} 7000 1250 0 0 {name=l757 lab=PREB}
C {devices/lab_pin.sym} 7100 1140 0 0 {name=l758 lab=VDD}
C {devices/lab_pin.sym} 7200 1350 0 0 {name=l759 lab=0}
C {devices/lab_pin.sym} 780 2020 0 0 {name=l760 lab=CA0}
C {devices/lab_pin.sym} 780 2045 0 0 {name=l761 lab=CA0B}
C {devices/lab_pin.sym} 780 2070 0 0 {name=l762 lab=CA1}
C {devices/lab_pin.sym} 780 2095 0 0 {name=l763 lab=CA1B}
C {devices/lab_pin.sym} 780 2120 0 0 {name=l764 lab=CA2}
C {devices/lab_pin.sym} 780 2145 0 0 {name=l765 lab=CA2B}
C {devices/lab_pin.sym} 780 2170 0 0 {name=l766 lab=CA3}
C {devices/lab_pin.sym} 780 2195 0 0 {name=l767 lab=CA3B}
C {devices/lab_pin.sym} 780 2220 0 0 {name=l768 lab=CA4}
C {devices/lab_pin.sym} 780 2245 0 0 {name=l769 lab=CA4B}
C {devices/lab_pin.sym} 4000 1960 0 0 {name=l770 lab=VDD}
C {devices/lab_pin.sym} 4000 2320 0 0 {name=l771 lab=0}
C {devices/lab_pin.sym} 5450 2790 0 0 {name=l772 lab=SAE}
C {devices/lab_pin.sym} 5750 2670 2 0 {name=l773 lab=SOUT}
C {devices/lab_pin.sym} 5750 2730 2 0 {name=l774 lab=SOUTB}
C {devices/noconn.sym} 5750 2730 0 0 {name=nc775}
C {devices/lab_pin.sym} 5600 2610 0 0 {name=l776 lab=VDD}
C {devices/lab_pin.sym} 5600 2850 0 0 {name=l777 lab=0}
C {devices/lab_pin.sym} 2400 2500 0 0 {name=l778 lab=PREB}
C {devices/lab_pin.sym} 2440 2470 0 0 {name=l779 lab=VDD}
C {devices/lab_pin.sym} 2440 2500 0 0 {name=l780 lab=VDD}
C {devices/lab_pin.sym} 2440 2970 0 0 {name=l781 lab=0}
C {devices/lab_pin.sym} 2440 2940 0 0 {name=l782 lab=0}
C {devices/lab_pin.sym} 1980 2880 0 0 {name=l783 lab=VDD}
C {devices/lab_pin.sym} 1930 2920 0 0 {name=l784 lab=DINB}
C {devices/lab_pin.sym} 1930 2960 0 0 {name=l785 lab=WRITE_EN}
C {devices/lab_pin.sym} 1980 3000 0 0 {name=l786 lab=0}
C {devices/lab_pin.sym} 3700 2500 0 0 {name=l787 lab=PREB}
C {devices/lab_pin.sym} 3740 2470 0 0 {name=l788 lab=VDD}
C {devices/lab_pin.sym} 3740 2500 0 0 {name=l789 lab=VDD}
C {devices/lab_pin.sym} 3740 2970 0 0 {name=l790 lab=0}
C {devices/lab_pin.sym} 3740 2940 0 0 {name=l791 lab=0}
C {devices/lab_pin.sym} 3280 2880 0 0 {name=l792 lab=VDD}
C {devices/lab_pin.sym} 3230 2920 0 0 {name=l793 lab=DIN}
C {devices/lab_pin.sym} 3230 2960 0 0 {name=l794 lab=WRITE_EN}
C {devices/lab_pin.sym} 3280 3000 0 0 {name=l795 lab=0}
C {devices/lab_pin.sym} -160 1920 0 0 {name=l796 lab=CLK}
C {devices/lab_pin.sym} -160 1980 0 0 {name=l797 lab=RESET}
C {devices/lab_pin.sym} -160 2040 0 0 {name=l798 lab=SDI}
C {devices/lab_pin.sym} -160 2100 0 0 {name=l799 lab=WE}
C {devices/lab_pin.sym} -160 2160 0 0 {name=l800 lab=SOUT}
C {devices/lab_pin.sym} 160 1320 2 0 {name=l801 lab=DIN}
C {devices/lab_pin.sym} 160 1380 2 0 {name=l802 lab=DINB}
C {devices/lab_pin.sym} 160 1440 2 0 {name=l803 lab=CA0}
C {devices/lab_pin.sym} 160 1500 2 0 {name=l804 lab=CA0B}
C {devices/lab_pin.sym} 160 1560 2 0 {name=l805 lab=CA1}
C {devices/lab_pin.sym} 160 1620 2 0 {name=l806 lab=CA1B}
C {devices/lab_pin.sym} 160 1680 2 0 {name=l807 lab=CA2}
C {devices/lab_pin.sym} 160 1740 2 0 {name=l808 lab=CA2B}
C {devices/lab_pin.sym} 160 1800 2 0 {name=l809 lab=CA3}
C {devices/lab_pin.sym} 160 1860 2 0 {name=l810 lab=CA3B}
C {devices/lab_pin.sym} 160 1920 2 0 {name=l811 lab=CA4}
C {devices/lab_pin.sym} 160 1980 2 0 {name=l812 lab=CA4B}
C {devices/lab_pin.sym} 160 2040 2 0 {name=l813 lab=RA0}
C {devices/lab_pin.sym} 160 2100 2 0 {name=l814 lab=RA0B}
C {devices/noconn.sym} 160 2100 0 0 {name=nc815}
C {devices/lab_pin.sym} 160 2160 2 0 {name=l816 lab=RA1}
C {devices/lab_pin.sym} 160 2220 2 0 {name=l817 lab=RA1B}
C {devices/noconn.sym} 160 2220 0 0 {name=nc818}
C {devices/lab_pin.sym} 160 2280 2 0 {name=l819 lab=RA2}
C {devices/lab_pin.sym} 160 2340 2 0 {name=l820 lab=RA2B}
C {devices/noconn.sym} 160 2340 0 0 {name=nc821}
C {devices/lab_pin.sym} 160 2400 2 0 {name=l822 lab=RA3}
C {devices/lab_pin.sym} 160 2460 2 0 {name=l823 lab=RA3B}
C {devices/noconn.sym} 160 2460 0 0 {name=nc824}
C {devices/lab_pin.sym} 160 2520 2 0 {name=l825 lab=PREB}
C {devices/lab_pin.sym} 160 2580 2 0 {name=l826 lab=SAE}
C {devices/lab_pin.sym} 160 2640 2 0 {name=l827 lab=WL_EN}
C {devices/lab_pin.sym} 160 2700 2 0 {name=l828 lab=WRITE_EN}
C {devices/lab_pin.sym} 160 2760 2 0 {name=l829 lab=SDO}
C {devices/noconn.sym} 160 2760 0 0 {name=nc830}
C {devices/lab_pin.sym} 0 1220 0 0 {name=l831 lab=VDD}
C {devices/lab_pin.sym} 0 2860 0 0 {name=l832 lab=0}
C {devices/lab_pin.sym} -1200 980 0 0 {name=l833 lab=CLK}
C {devices/lab_pin.sym} -1100 860 0 0 {name=l834 lab=VDD}
C {devices/lab_pin.sym} -1100 1100 0 0 {name=l835 lab=0}
C {devices/lab_pin.sym} -780 980 0 0 {name=l836 lab=RESET}
C {devices/lab_pin.sym} -680 860 0 0 {name=l837 lab=VDD}
C {devices/lab_pin.sym} -680 1100 0 0 {name=l838 lab=0}
C {devices/lab_pin.sym} -360 980 0 0 {name=l839 lab=SDI}
C {devices/lab_pin.sym} -260 860 0 0 {name=l840 lab=VDD}
C {devices/lab_pin.sym} -260 1100 0 0 {name=l841 lab=0}
C {devices/lab_pin.sym} 60 980 0 0 {name=l842 lab=WE}
C {devices/lab_pin.sym} 160 860 0 0 {name=l843 lab=VDD}
C {devices/lab_pin.sym} 160 1100 0 0 {name=l844 lab=0}
