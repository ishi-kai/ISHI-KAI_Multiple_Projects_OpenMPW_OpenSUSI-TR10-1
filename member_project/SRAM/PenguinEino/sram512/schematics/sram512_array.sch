v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
E {}
T {512-bit 6T ARRAY | 16 rows x 32 columns | minimum 3.4/1 um MOS} -300 -440 0 0 0.5 0.5 {}
C {sram512_bitcell.sym} 0 0 0 0 {name=xr0c0}
N -100 0 -130 0 {lab=WL0}
N -130 0 -130 100 {lab=WL0}
N -40 -100 -110 -100 {lab=BL0}
N 40 -100 110 -100 {lab=BLB0}
C {sram512_bitcell.sym} 320 0 0 0 {name=xr0c1}
N 220 0 190 0 {lab=WL0}
N 190 0 190 100 {lab=WL0}
N 280 -100 210 -100 {lab=BL1}
N 360 -100 430 -100 {lab=BLB1}
C {sram512_bitcell.sym} 640 0 0 0 {name=xr0c2}
N 540 0 510 0 {lab=WL0}
N 510 0 510 100 {lab=WL0}
N 600 -100 530 -100 {lab=BL2}
N 680 -100 750 -100 {lab=BLB2}
C {sram512_bitcell.sym} 960 0 0 0 {name=xr0c3}
N 860 0 830 0 {lab=WL0}
N 830 0 830 100 {lab=WL0}
N 920 -100 850 -100 {lab=BL3}
N 1000 -100 1070 -100 {lab=BLB3}
C {sram512_bitcell.sym} 1280 0 0 0 {name=xr0c4}
N 1180 0 1150 0 {lab=WL0}
N 1150 0 1150 100 {lab=WL0}
N 1240 -100 1170 -100 {lab=BL4}
N 1320 -100 1390 -100 {lab=BLB4}
C {sram512_bitcell.sym} 1600 0 0 0 {name=xr0c5}
N 1500 0 1470 0 {lab=WL0}
N 1470 0 1470 100 {lab=WL0}
N 1560 -100 1490 -100 {lab=BL5}
N 1640 -100 1710 -100 {lab=BLB5}
C {sram512_bitcell.sym} 1920 0 0 0 {name=xr0c6}
N 1820 0 1790 0 {lab=WL0}
N 1790 0 1790 100 {lab=WL0}
N 1880 -100 1810 -100 {lab=BL6}
N 1960 -100 2030 -100 {lab=BLB6}
C {sram512_bitcell.sym} 2240 0 0 0 {name=xr0c7}
N 2140 0 2110 0 {lab=WL0}
N 2110 0 2110 100 {lab=WL0}
N 2200 -100 2130 -100 {lab=BL7}
N 2280 -100 2350 -100 {lab=BLB7}
C {sram512_bitcell.sym} 2560 0 0 0 {name=xr0c8}
N 2460 0 2430 0 {lab=WL0}
N 2430 0 2430 100 {lab=WL0}
N 2520 -100 2450 -100 {lab=BL8}
N 2600 -100 2670 -100 {lab=BLB8}
C {sram512_bitcell.sym} 2880 0 0 0 {name=xr0c9}
N 2780 0 2750 0 {lab=WL0}
N 2750 0 2750 100 {lab=WL0}
N 2840 -100 2770 -100 {lab=BL9}
N 2920 -100 2990 -100 {lab=BLB9}
C {sram512_bitcell.sym} 3200 0 0 0 {name=xr0c10}
N 3100 0 3070 0 {lab=WL0}
N 3070 0 3070 100 {lab=WL0}
N 3160 -100 3090 -100 {lab=BL10}
N 3240 -100 3310 -100 {lab=BLB10}
C {sram512_bitcell.sym} 3520 0 0 0 {name=xr0c11}
N 3420 0 3390 0 {lab=WL0}
N 3390 0 3390 100 {lab=WL0}
N 3480 -100 3410 -100 {lab=BL11}
N 3560 -100 3630 -100 {lab=BLB11}
C {sram512_bitcell.sym} 3840 0 0 0 {name=xr0c12}
N 3740 0 3710 0 {lab=WL0}
N 3710 0 3710 100 {lab=WL0}
N 3800 -100 3730 -100 {lab=BL12}
N 3880 -100 3950 -100 {lab=BLB12}
C {sram512_bitcell.sym} 4160 0 0 0 {name=xr0c13}
N 4060 0 4030 0 {lab=WL0}
N 4030 0 4030 100 {lab=WL0}
N 4120 -100 4050 -100 {lab=BL13}
N 4200 -100 4270 -100 {lab=BLB13}
C {sram512_bitcell.sym} 4480 0 0 0 {name=xr0c14}
N 4380 0 4350 0 {lab=WL0}
N 4350 0 4350 100 {lab=WL0}
N 4440 -100 4370 -100 {lab=BL14}
N 4520 -100 4590 -100 {lab=BLB14}
C {sram512_bitcell.sym} 4800 0 0 0 {name=xr0c15}
N 4700 0 4670 0 {lab=WL0}
N 4670 0 4670 100 {lab=WL0}
N 4760 -100 4690 -100 {lab=BL15}
N 4840 -100 4910 -100 {lab=BLB15}
C {sram512_bitcell.sym} 5120 0 0 0 {name=xr0c16}
N 5020 0 4990 0 {lab=WL0}
N 4990 0 4990 100 {lab=WL0}
N 5080 -100 5010 -100 {lab=BL16}
N 5160 -100 5230 -100 {lab=BLB16}
C {sram512_bitcell.sym} 5440 0 0 0 {name=xr0c17}
N 5340 0 5310 0 {lab=WL0}
N 5310 0 5310 100 {lab=WL0}
N 5400 -100 5330 -100 {lab=BL17}
N 5480 -100 5550 -100 {lab=BLB17}
C {sram512_bitcell.sym} 5760 0 0 0 {name=xr0c18}
N 5660 0 5630 0 {lab=WL0}
N 5630 0 5630 100 {lab=WL0}
N 5720 -100 5650 -100 {lab=BL18}
N 5800 -100 5870 -100 {lab=BLB18}
C {sram512_bitcell.sym} 6080 0 0 0 {name=xr0c19}
N 5980 0 5950 0 {lab=WL0}
N 5950 0 5950 100 {lab=WL0}
N 6040 -100 5970 -100 {lab=BL19}
N 6120 -100 6190 -100 {lab=BLB19}
C {sram512_bitcell.sym} 6400 0 0 0 {name=xr0c20}
N 6300 0 6270 0 {lab=WL0}
N 6270 0 6270 100 {lab=WL0}
N 6360 -100 6290 -100 {lab=BL20}
N 6440 -100 6510 -100 {lab=BLB20}
C {sram512_bitcell.sym} 6720 0 0 0 {name=xr0c21}
N 6620 0 6590 0 {lab=WL0}
N 6590 0 6590 100 {lab=WL0}
N 6680 -100 6610 -100 {lab=BL21}
N 6760 -100 6830 -100 {lab=BLB21}
C {sram512_bitcell.sym} 7040 0 0 0 {name=xr0c22}
N 6940 0 6910 0 {lab=WL0}
N 6910 0 6910 100 {lab=WL0}
N 7000 -100 6930 -100 {lab=BL22}
N 7080 -100 7150 -100 {lab=BLB22}
C {sram512_bitcell.sym} 7360 0 0 0 {name=xr0c23}
N 7260 0 7230 0 {lab=WL0}
N 7230 0 7230 100 {lab=WL0}
N 7320 -100 7250 -100 {lab=BL23}
N 7400 -100 7470 -100 {lab=BLB23}
C {sram512_bitcell.sym} 7680 0 0 0 {name=xr0c24}
N 7580 0 7550 0 {lab=WL0}
N 7550 0 7550 100 {lab=WL0}
N 7640 -100 7570 -100 {lab=BL24}
N 7720 -100 7790 -100 {lab=BLB24}
C {sram512_bitcell.sym} 8000 0 0 0 {name=xr0c25}
N 7900 0 7870 0 {lab=WL0}
N 7870 0 7870 100 {lab=WL0}
N 7960 -100 7890 -100 {lab=BL25}
N 8040 -100 8110 -100 {lab=BLB25}
C {sram512_bitcell.sym} 8320 0 0 0 {name=xr0c26}
N 8220 0 8190 0 {lab=WL0}
N 8190 0 8190 100 {lab=WL0}
N 8280 -100 8210 -100 {lab=BL26}
N 8360 -100 8430 -100 {lab=BLB26}
C {sram512_bitcell.sym} 8640 0 0 0 {name=xr0c27}
N 8540 0 8510 0 {lab=WL0}
N 8510 0 8510 100 {lab=WL0}
N 8600 -100 8530 -100 {lab=BL27}
N 8680 -100 8750 -100 {lab=BLB27}
C {sram512_bitcell.sym} 8960 0 0 0 {name=xr0c28}
N 8860 0 8830 0 {lab=WL0}
N 8830 0 8830 100 {lab=WL0}
N 8920 -100 8850 -100 {lab=BL28}
N 9000 -100 9070 -100 {lab=BLB28}
C {sram512_bitcell.sym} 9280 0 0 0 {name=xr0c29}
N 9180 0 9150 0 {lab=WL0}
N 9150 0 9150 100 {lab=WL0}
N 9240 -100 9170 -100 {lab=BL29}
N 9320 -100 9390 -100 {lab=BLB29}
C {sram512_bitcell.sym} 9600 0 0 0 {name=xr0c30}
N 9500 0 9470 0 {lab=WL0}
N 9470 0 9470 100 {lab=WL0}
N 9560 -100 9490 -100 {lab=BL30}
N 9640 -100 9710 -100 {lab=BLB30}
C {sram512_bitcell.sym} 9920 0 0 0 {name=xr0c31}
N 9820 0 9790 0 {lab=WL0}
N 9790 0 9790 100 {lab=WL0}
N 9880 -100 9810 -100 {lab=BL31}
N 9960 -100 10030 -100 {lab=BLB31}
N -300 100 9790 100 {lab=WL0}
C {devices/ipin.sym} -300 100 0 0 {name=pWL0 lab=WL0}
C {sram512_bitcell.sym} 0 280 0 0 {name=xr1c0}
N -100 280 -130 280 {lab=WL1}
N -130 280 -130 380 {lab=WL1}
N -40 180 -110 180 {lab=BL0}
N 40 180 110 180 {lab=BLB0}
C {sram512_bitcell.sym} 320 280 0 0 {name=xr1c1}
N 220 280 190 280 {lab=WL1}
N 190 280 190 380 {lab=WL1}
N 280 180 210 180 {lab=BL1}
N 360 180 430 180 {lab=BLB1}
C {sram512_bitcell.sym} 640 280 0 0 {name=xr1c2}
N 540 280 510 280 {lab=WL1}
N 510 280 510 380 {lab=WL1}
N 600 180 530 180 {lab=BL2}
N 680 180 750 180 {lab=BLB2}
C {sram512_bitcell.sym} 960 280 0 0 {name=xr1c3}
N 860 280 830 280 {lab=WL1}
N 830 280 830 380 {lab=WL1}
N 920 180 850 180 {lab=BL3}
N 1000 180 1070 180 {lab=BLB3}
C {sram512_bitcell.sym} 1280 280 0 0 {name=xr1c4}
N 1180 280 1150 280 {lab=WL1}
N 1150 280 1150 380 {lab=WL1}
N 1240 180 1170 180 {lab=BL4}
N 1320 180 1390 180 {lab=BLB4}
C {sram512_bitcell.sym} 1600 280 0 0 {name=xr1c5}
N 1500 280 1470 280 {lab=WL1}
N 1470 280 1470 380 {lab=WL1}
N 1560 180 1490 180 {lab=BL5}
N 1640 180 1710 180 {lab=BLB5}
C {sram512_bitcell.sym} 1920 280 0 0 {name=xr1c6}
N 1820 280 1790 280 {lab=WL1}
N 1790 280 1790 380 {lab=WL1}
N 1880 180 1810 180 {lab=BL6}
N 1960 180 2030 180 {lab=BLB6}
C {sram512_bitcell.sym} 2240 280 0 0 {name=xr1c7}
N 2140 280 2110 280 {lab=WL1}
N 2110 280 2110 380 {lab=WL1}
N 2200 180 2130 180 {lab=BL7}
N 2280 180 2350 180 {lab=BLB7}
C {sram512_bitcell.sym} 2560 280 0 0 {name=xr1c8}
N 2460 280 2430 280 {lab=WL1}
N 2430 280 2430 380 {lab=WL1}
N 2520 180 2450 180 {lab=BL8}
N 2600 180 2670 180 {lab=BLB8}
C {sram512_bitcell.sym} 2880 280 0 0 {name=xr1c9}
N 2780 280 2750 280 {lab=WL1}
N 2750 280 2750 380 {lab=WL1}
N 2840 180 2770 180 {lab=BL9}
N 2920 180 2990 180 {lab=BLB9}
C {sram512_bitcell.sym} 3200 280 0 0 {name=xr1c10}
N 3100 280 3070 280 {lab=WL1}
N 3070 280 3070 380 {lab=WL1}
N 3160 180 3090 180 {lab=BL10}
N 3240 180 3310 180 {lab=BLB10}
C {sram512_bitcell.sym} 3520 280 0 0 {name=xr1c11}
N 3420 280 3390 280 {lab=WL1}
N 3390 280 3390 380 {lab=WL1}
N 3480 180 3410 180 {lab=BL11}
N 3560 180 3630 180 {lab=BLB11}
C {sram512_bitcell.sym} 3840 280 0 0 {name=xr1c12}
N 3740 280 3710 280 {lab=WL1}
N 3710 280 3710 380 {lab=WL1}
N 3800 180 3730 180 {lab=BL12}
N 3880 180 3950 180 {lab=BLB12}
C {sram512_bitcell.sym} 4160 280 0 0 {name=xr1c13}
N 4060 280 4030 280 {lab=WL1}
N 4030 280 4030 380 {lab=WL1}
N 4120 180 4050 180 {lab=BL13}
N 4200 180 4270 180 {lab=BLB13}
C {sram512_bitcell.sym} 4480 280 0 0 {name=xr1c14}
N 4380 280 4350 280 {lab=WL1}
N 4350 280 4350 380 {lab=WL1}
N 4440 180 4370 180 {lab=BL14}
N 4520 180 4590 180 {lab=BLB14}
C {sram512_bitcell.sym} 4800 280 0 0 {name=xr1c15}
N 4700 280 4670 280 {lab=WL1}
N 4670 280 4670 380 {lab=WL1}
N 4760 180 4690 180 {lab=BL15}
N 4840 180 4910 180 {lab=BLB15}
C {sram512_bitcell.sym} 5120 280 0 0 {name=xr1c16}
N 5020 280 4990 280 {lab=WL1}
N 4990 280 4990 380 {lab=WL1}
N 5080 180 5010 180 {lab=BL16}
N 5160 180 5230 180 {lab=BLB16}
C {sram512_bitcell.sym} 5440 280 0 0 {name=xr1c17}
N 5340 280 5310 280 {lab=WL1}
N 5310 280 5310 380 {lab=WL1}
N 5400 180 5330 180 {lab=BL17}
N 5480 180 5550 180 {lab=BLB17}
C {sram512_bitcell.sym} 5760 280 0 0 {name=xr1c18}
N 5660 280 5630 280 {lab=WL1}
N 5630 280 5630 380 {lab=WL1}
N 5720 180 5650 180 {lab=BL18}
N 5800 180 5870 180 {lab=BLB18}
C {sram512_bitcell.sym} 6080 280 0 0 {name=xr1c19}
N 5980 280 5950 280 {lab=WL1}
N 5950 280 5950 380 {lab=WL1}
N 6040 180 5970 180 {lab=BL19}
N 6120 180 6190 180 {lab=BLB19}
C {sram512_bitcell.sym} 6400 280 0 0 {name=xr1c20}
N 6300 280 6270 280 {lab=WL1}
N 6270 280 6270 380 {lab=WL1}
N 6360 180 6290 180 {lab=BL20}
N 6440 180 6510 180 {lab=BLB20}
C {sram512_bitcell.sym} 6720 280 0 0 {name=xr1c21}
N 6620 280 6590 280 {lab=WL1}
N 6590 280 6590 380 {lab=WL1}
N 6680 180 6610 180 {lab=BL21}
N 6760 180 6830 180 {lab=BLB21}
C {sram512_bitcell.sym} 7040 280 0 0 {name=xr1c22}
N 6940 280 6910 280 {lab=WL1}
N 6910 280 6910 380 {lab=WL1}
N 7000 180 6930 180 {lab=BL22}
N 7080 180 7150 180 {lab=BLB22}
C {sram512_bitcell.sym} 7360 280 0 0 {name=xr1c23}
N 7260 280 7230 280 {lab=WL1}
N 7230 280 7230 380 {lab=WL1}
N 7320 180 7250 180 {lab=BL23}
N 7400 180 7470 180 {lab=BLB23}
C {sram512_bitcell.sym} 7680 280 0 0 {name=xr1c24}
N 7580 280 7550 280 {lab=WL1}
N 7550 280 7550 380 {lab=WL1}
N 7640 180 7570 180 {lab=BL24}
N 7720 180 7790 180 {lab=BLB24}
C {sram512_bitcell.sym} 8000 280 0 0 {name=xr1c25}
N 7900 280 7870 280 {lab=WL1}
N 7870 280 7870 380 {lab=WL1}
N 7960 180 7890 180 {lab=BL25}
N 8040 180 8110 180 {lab=BLB25}
C {sram512_bitcell.sym} 8320 280 0 0 {name=xr1c26}
N 8220 280 8190 280 {lab=WL1}
N 8190 280 8190 380 {lab=WL1}
N 8280 180 8210 180 {lab=BL26}
N 8360 180 8430 180 {lab=BLB26}
C {sram512_bitcell.sym} 8640 280 0 0 {name=xr1c27}
N 8540 280 8510 280 {lab=WL1}
N 8510 280 8510 380 {lab=WL1}
N 8600 180 8530 180 {lab=BL27}
N 8680 180 8750 180 {lab=BLB27}
C {sram512_bitcell.sym} 8960 280 0 0 {name=xr1c28}
N 8860 280 8830 280 {lab=WL1}
N 8830 280 8830 380 {lab=WL1}
N 8920 180 8850 180 {lab=BL28}
N 9000 180 9070 180 {lab=BLB28}
C {sram512_bitcell.sym} 9280 280 0 0 {name=xr1c29}
N 9180 280 9150 280 {lab=WL1}
N 9150 280 9150 380 {lab=WL1}
N 9240 180 9170 180 {lab=BL29}
N 9320 180 9390 180 {lab=BLB29}
C {sram512_bitcell.sym} 9600 280 0 0 {name=xr1c30}
N 9500 280 9470 280 {lab=WL1}
N 9470 280 9470 380 {lab=WL1}
N 9560 180 9490 180 {lab=BL30}
N 9640 180 9710 180 {lab=BLB30}
C {sram512_bitcell.sym} 9920 280 0 0 {name=xr1c31}
N 9820 280 9790 280 {lab=WL1}
N 9790 280 9790 380 {lab=WL1}
N 9880 180 9810 180 {lab=BL31}
N 9960 180 10030 180 {lab=BLB31}
N -300 380 9790 380 {lab=WL1}
C {devices/ipin.sym} -300 380 0 0 {name=pWL1 lab=WL1}
C {sram512_bitcell.sym} 0 560 0 0 {name=xr2c0}
N -100 560 -130 560 {lab=WL2}
N -130 560 -130 660 {lab=WL2}
N -40 460 -110 460 {lab=BL0}
N 40 460 110 460 {lab=BLB0}
C {sram512_bitcell.sym} 320 560 0 0 {name=xr2c1}
N 220 560 190 560 {lab=WL2}
N 190 560 190 660 {lab=WL2}
N 280 460 210 460 {lab=BL1}
N 360 460 430 460 {lab=BLB1}
C {sram512_bitcell.sym} 640 560 0 0 {name=xr2c2}
N 540 560 510 560 {lab=WL2}
N 510 560 510 660 {lab=WL2}
N 600 460 530 460 {lab=BL2}
N 680 460 750 460 {lab=BLB2}
C {sram512_bitcell.sym} 960 560 0 0 {name=xr2c3}
N 860 560 830 560 {lab=WL2}
N 830 560 830 660 {lab=WL2}
N 920 460 850 460 {lab=BL3}
N 1000 460 1070 460 {lab=BLB3}
C {sram512_bitcell.sym} 1280 560 0 0 {name=xr2c4}
N 1180 560 1150 560 {lab=WL2}
N 1150 560 1150 660 {lab=WL2}
N 1240 460 1170 460 {lab=BL4}
N 1320 460 1390 460 {lab=BLB4}
C {sram512_bitcell.sym} 1600 560 0 0 {name=xr2c5}
N 1500 560 1470 560 {lab=WL2}
N 1470 560 1470 660 {lab=WL2}
N 1560 460 1490 460 {lab=BL5}
N 1640 460 1710 460 {lab=BLB5}
C {sram512_bitcell.sym} 1920 560 0 0 {name=xr2c6}
N 1820 560 1790 560 {lab=WL2}
N 1790 560 1790 660 {lab=WL2}
N 1880 460 1810 460 {lab=BL6}
N 1960 460 2030 460 {lab=BLB6}
C {sram512_bitcell.sym} 2240 560 0 0 {name=xr2c7}
N 2140 560 2110 560 {lab=WL2}
N 2110 560 2110 660 {lab=WL2}
N 2200 460 2130 460 {lab=BL7}
N 2280 460 2350 460 {lab=BLB7}
C {sram512_bitcell.sym} 2560 560 0 0 {name=xr2c8}
N 2460 560 2430 560 {lab=WL2}
N 2430 560 2430 660 {lab=WL2}
N 2520 460 2450 460 {lab=BL8}
N 2600 460 2670 460 {lab=BLB8}
C {sram512_bitcell.sym} 2880 560 0 0 {name=xr2c9}
N 2780 560 2750 560 {lab=WL2}
N 2750 560 2750 660 {lab=WL2}
N 2840 460 2770 460 {lab=BL9}
N 2920 460 2990 460 {lab=BLB9}
C {sram512_bitcell.sym} 3200 560 0 0 {name=xr2c10}
N 3100 560 3070 560 {lab=WL2}
N 3070 560 3070 660 {lab=WL2}
N 3160 460 3090 460 {lab=BL10}
N 3240 460 3310 460 {lab=BLB10}
C {sram512_bitcell.sym} 3520 560 0 0 {name=xr2c11}
N 3420 560 3390 560 {lab=WL2}
N 3390 560 3390 660 {lab=WL2}
N 3480 460 3410 460 {lab=BL11}
N 3560 460 3630 460 {lab=BLB11}
C {sram512_bitcell.sym} 3840 560 0 0 {name=xr2c12}
N 3740 560 3710 560 {lab=WL2}
N 3710 560 3710 660 {lab=WL2}
N 3800 460 3730 460 {lab=BL12}
N 3880 460 3950 460 {lab=BLB12}
C {sram512_bitcell.sym} 4160 560 0 0 {name=xr2c13}
N 4060 560 4030 560 {lab=WL2}
N 4030 560 4030 660 {lab=WL2}
N 4120 460 4050 460 {lab=BL13}
N 4200 460 4270 460 {lab=BLB13}
C {sram512_bitcell.sym} 4480 560 0 0 {name=xr2c14}
N 4380 560 4350 560 {lab=WL2}
N 4350 560 4350 660 {lab=WL2}
N 4440 460 4370 460 {lab=BL14}
N 4520 460 4590 460 {lab=BLB14}
C {sram512_bitcell.sym} 4800 560 0 0 {name=xr2c15}
N 4700 560 4670 560 {lab=WL2}
N 4670 560 4670 660 {lab=WL2}
N 4760 460 4690 460 {lab=BL15}
N 4840 460 4910 460 {lab=BLB15}
C {sram512_bitcell.sym} 5120 560 0 0 {name=xr2c16}
N 5020 560 4990 560 {lab=WL2}
N 4990 560 4990 660 {lab=WL2}
N 5080 460 5010 460 {lab=BL16}
N 5160 460 5230 460 {lab=BLB16}
C {sram512_bitcell.sym} 5440 560 0 0 {name=xr2c17}
N 5340 560 5310 560 {lab=WL2}
N 5310 560 5310 660 {lab=WL2}
N 5400 460 5330 460 {lab=BL17}
N 5480 460 5550 460 {lab=BLB17}
C {sram512_bitcell.sym} 5760 560 0 0 {name=xr2c18}
N 5660 560 5630 560 {lab=WL2}
N 5630 560 5630 660 {lab=WL2}
N 5720 460 5650 460 {lab=BL18}
N 5800 460 5870 460 {lab=BLB18}
C {sram512_bitcell.sym} 6080 560 0 0 {name=xr2c19}
N 5980 560 5950 560 {lab=WL2}
N 5950 560 5950 660 {lab=WL2}
N 6040 460 5970 460 {lab=BL19}
N 6120 460 6190 460 {lab=BLB19}
C {sram512_bitcell.sym} 6400 560 0 0 {name=xr2c20}
N 6300 560 6270 560 {lab=WL2}
N 6270 560 6270 660 {lab=WL2}
N 6360 460 6290 460 {lab=BL20}
N 6440 460 6510 460 {lab=BLB20}
C {sram512_bitcell.sym} 6720 560 0 0 {name=xr2c21}
N 6620 560 6590 560 {lab=WL2}
N 6590 560 6590 660 {lab=WL2}
N 6680 460 6610 460 {lab=BL21}
N 6760 460 6830 460 {lab=BLB21}
C {sram512_bitcell.sym} 7040 560 0 0 {name=xr2c22}
N 6940 560 6910 560 {lab=WL2}
N 6910 560 6910 660 {lab=WL2}
N 7000 460 6930 460 {lab=BL22}
N 7080 460 7150 460 {lab=BLB22}
C {sram512_bitcell.sym} 7360 560 0 0 {name=xr2c23}
N 7260 560 7230 560 {lab=WL2}
N 7230 560 7230 660 {lab=WL2}
N 7320 460 7250 460 {lab=BL23}
N 7400 460 7470 460 {lab=BLB23}
C {sram512_bitcell.sym} 7680 560 0 0 {name=xr2c24}
N 7580 560 7550 560 {lab=WL2}
N 7550 560 7550 660 {lab=WL2}
N 7640 460 7570 460 {lab=BL24}
N 7720 460 7790 460 {lab=BLB24}
C {sram512_bitcell.sym} 8000 560 0 0 {name=xr2c25}
N 7900 560 7870 560 {lab=WL2}
N 7870 560 7870 660 {lab=WL2}
N 7960 460 7890 460 {lab=BL25}
N 8040 460 8110 460 {lab=BLB25}
C {sram512_bitcell.sym} 8320 560 0 0 {name=xr2c26}
N 8220 560 8190 560 {lab=WL2}
N 8190 560 8190 660 {lab=WL2}
N 8280 460 8210 460 {lab=BL26}
N 8360 460 8430 460 {lab=BLB26}
C {sram512_bitcell.sym} 8640 560 0 0 {name=xr2c27}
N 8540 560 8510 560 {lab=WL2}
N 8510 560 8510 660 {lab=WL2}
N 8600 460 8530 460 {lab=BL27}
N 8680 460 8750 460 {lab=BLB27}
C {sram512_bitcell.sym} 8960 560 0 0 {name=xr2c28}
N 8860 560 8830 560 {lab=WL2}
N 8830 560 8830 660 {lab=WL2}
N 8920 460 8850 460 {lab=BL28}
N 9000 460 9070 460 {lab=BLB28}
C {sram512_bitcell.sym} 9280 560 0 0 {name=xr2c29}
N 9180 560 9150 560 {lab=WL2}
N 9150 560 9150 660 {lab=WL2}
N 9240 460 9170 460 {lab=BL29}
N 9320 460 9390 460 {lab=BLB29}
C {sram512_bitcell.sym} 9600 560 0 0 {name=xr2c30}
N 9500 560 9470 560 {lab=WL2}
N 9470 560 9470 660 {lab=WL2}
N 9560 460 9490 460 {lab=BL30}
N 9640 460 9710 460 {lab=BLB30}
C {sram512_bitcell.sym} 9920 560 0 0 {name=xr2c31}
N 9820 560 9790 560 {lab=WL2}
N 9790 560 9790 660 {lab=WL2}
N 9880 460 9810 460 {lab=BL31}
N 9960 460 10030 460 {lab=BLB31}
N -300 660 9790 660 {lab=WL2}
C {devices/ipin.sym} -300 660 0 0 {name=pWL2 lab=WL2}
C {sram512_bitcell.sym} 0 840 0 0 {name=xr3c0}
N -100 840 -130 840 {lab=WL3}
N -130 840 -130 940 {lab=WL3}
N -40 740 -110 740 {lab=BL0}
N 40 740 110 740 {lab=BLB0}
C {sram512_bitcell.sym} 320 840 0 0 {name=xr3c1}
N 220 840 190 840 {lab=WL3}
N 190 840 190 940 {lab=WL3}
N 280 740 210 740 {lab=BL1}
N 360 740 430 740 {lab=BLB1}
C {sram512_bitcell.sym} 640 840 0 0 {name=xr3c2}
N 540 840 510 840 {lab=WL3}
N 510 840 510 940 {lab=WL3}
N 600 740 530 740 {lab=BL2}
N 680 740 750 740 {lab=BLB2}
C {sram512_bitcell.sym} 960 840 0 0 {name=xr3c3}
N 860 840 830 840 {lab=WL3}
N 830 840 830 940 {lab=WL3}
N 920 740 850 740 {lab=BL3}
N 1000 740 1070 740 {lab=BLB3}
C {sram512_bitcell.sym} 1280 840 0 0 {name=xr3c4}
N 1180 840 1150 840 {lab=WL3}
N 1150 840 1150 940 {lab=WL3}
N 1240 740 1170 740 {lab=BL4}
N 1320 740 1390 740 {lab=BLB4}
C {sram512_bitcell.sym} 1600 840 0 0 {name=xr3c5}
N 1500 840 1470 840 {lab=WL3}
N 1470 840 1470 940 {lab=WL3}
N 1560 740 1490 740 {lab=BL5}
N 1640 740 1710 740 {lab=BLB5}
C {sram512_bitcell.sym} 1920 840 0 0 {name=xr3c6}
N 1820 840 1790 840 {lab=WL3}
N 1790 840 1790 940 {lab=WL3}
N 1880 740 1810 740 {lab=BL6}
N 1960 740 2030 740 {lab=BLB6}
C {sram512_bitcell.sym} 2240 840 0 0 {name=xr3c7}
N 2140 840 2110 840 {lab=WL3}
N 2110 840 2110 940 {lab=WL3}
N 2200 740 2130 740 {lab=BL7}
N 2280 740 2350 740 {lab=BLB7}
C {sram512_bitcell.sym} 2560 840 0 0 {name=xr3c8}
N 2460 840 2430 840 {lab=WL3}
N 2430 840 2430 940 {lab=WL3}
N 2520 740 2450 740 {lab=BL8}
N 2600 740 2670 740 {lab=BLB8}
C {sram512_bitcell.sym} 2880 840 0 0 {name=xr3c9}
N 2780 840 2750 840 {lab=WL3}
N 2750 840 2750 940 {lab=WL3}
N 2840 740 2770 740 {lab=BL9}
N 2920 740 2990 740 {lab=BLB9}
C {sram512_bitcell.sym} 3200 840 0 0 {name=xr3c10}
N 3100 840 3070 840 {lab=WL3}
N 3070 840 3070 940 {lab=WL3}
N 3160 740 3090 740 {lab=BL10}
N 3240 740 3310 740 {lab=BLB10}
C {sram512_bitcell.sym} 3520 840 0 0 {name=xr3c11}
N 3420 840 3390 840 {lab=WL3}
N 3390 840 3390 940 {lab=WL3}
N 3480 740 3410 740 {lab=BL11}
N 3560 740 3630 740 {lab=BLB11}
C {sram512_bitcell.sym} 3840 840 0 0 {name=xr3c12}
N 3740 840 3710 840 {lab=WL3}
N 3710 840 3710 940 {lab=WL3}
N 3800 740 3730 740 {lab=BL12}
N 3880 740 3950 740 {lab=BLB12}
C {sram512_bitcell.sym} 4160 840 0 0 {name=xr3c13}
N 4060 840 4030 840 {lab=WL3}
N 4030 840 4030 940 {lab=WL3}
N 4120 740 4050 740 {lab=BL13}
N 4200 740 4270 740 {lab=BLB13}
C {sram512_bitcell.sym} 4480 840 0 0 {name=xr3c14}
N 4380 840 4350 840 {lab=WL3}
N 4350 840 4350 940 {lab=WL3}
N 4440 740 4370 740 {lab=BL14}
N 4520 740 4590 740 {lab=BLB14}
C {sram512_bitcell.sym} 4800 840 0 0 {name=xr3c15}
N 4700 840 4670 840 {lab=WL3}
N 4670 840 4670 940 {lab=WL3}
N 4760 740 4690 740 {lab=BL15}
N 4840 740 4910 740 {lab=BLB15}
C {sram512_bitcell.sym} 5120 840 0 0 {name=xr3c16}
N 5020 840 4990 840 {lab=WL3}
N 4990 840 4990 940 {lab=WL3}
N 5080 740 5010 740 {lab=BL16}
N 5160 740 5230 740 {lab=BLB16}
C {sram512_bitcell.sym} 5440 840 0 0 {name=xr3c17}
N 5340 840 5310 840 {lab=WL3}
N 5310 840 5310 940 {lab=WL3}
N 5400 740 5330 740 {lab=BL17}
N 5480 740 5550 740 {lab=BLB17}
C {sram512_bitcell.sym} 5760 840 0 0 {name=xr3c18}
N 5660 840 5630 840 {lab=WL3}
N 5630 840 5630 940 {lab=WL3}
N 5720 740 5650 740 {lab=BL18}
N 5800 740 5870 740 {lab=BLB18}
C {sram512_bitcell.sym} 6080 840 0 0 {name=xr3c19}
N 5980 840 5950 840 {lab=WL3}
N 5950 840 5950 940 {lab=WL3}
N 6040 740 5970 740 {lab=BL19}
N 6120 740 6190 740 {lab=BLB19}
C {sram512_bitcell.sym} 6400 840 0 0 {name=xr3c20}
N 6300 840 6270 840 {lab=WL3}
N 6270 840 6270 940 {lab=WL3}
N 6360 740 6290 740 {lab=BL20}
N 6440 740 6510 740 {lab=BLB20}
C {sram512_bitcell.sym} 6720 840 0 0 {name=xr3c21}
N 6620 840 6590 840 {lab=WL3}
N 6590 840 6590 940 {lab=WL3}
N 6680 740 6610 740 {lab=BL21}
N 6760 740 6830 740 {lab=BLB21}
C {sram512_bitcell.sym} 7040 840 0 0 {name=xr3c22}
N 6940 840 6910 840 {lab=WL3}
N 6910 840 6910 940 {lab=WL3}
N 7000 740 6930 740 {lab=BL22}
N 7080 740 7150 740 {lab=BLB22}
C {sram512_bitcell.sym} 7360 840 0 0 {name=xr3c23}
N 7260 840 7230 840 {lab=WL3}
N 7230 840 7230 940 {lab=WL3}
N 7320 740 7250 740 {lab=BL23}
N 7400 740 7470 740 {lab=BLB23}
C {sram512_bitcell.sym} 7680 840 0 0 {name=xr3c24}
N 7580 840 7550 840 {lab=WL3}
N 7550 840 7550 940 {lab=WL3}
N 7640 740 7570 740 {lab=BL24}
N 7720 740 7790 740 {lab=BLB24}
C {sram512_bitcell.sym} 8000 840 0 0 {name=xr3c25}
N 7900 840 7870 840 {lab=WL3}
N 7870 840 7870 940 {lab=WL3}
N 7960 740 7890 740 {lab=BL25}
N 8040 740 8110 740 {lab=BLB25}
C {sram512_bitcell.sym} 8320 840 0 0 {name=xr3c26}
N 8220 840 8190 840 {lab=WL3}
N 8190 840 8190 940 {lab=WL3}
N 8280 740 8210 740 {lab=BL26}
N 8360 740 8430 740 {lab=BLB26}
C {sram512_bitcell.sym} 8640 840 0 0 {name=xr3c27}
N 8540 840 8510 840 {lab=WL3}
N 8510 840 8510 940 {lab=WL3}
N 8600 740 8530 740 {lab=BL27}
N 8680 740 8750 740 {lab=BLB27}
C {sram512_bitcell.sym} 8960 840 0 0 {name=xr3c28}
N 8860 840 8830 840 {lab=WL3}
N 8830 840 8830 940 {lab=WL3}
N 8920 740 8850 740 {lab=BL28}
N 9000 740 9070 740 {lab=BLB28}
C {sram512_bitcell.sym} 9280 840 0 0 {name=xr3c29}
N 9180 840 9150 840 {lab=WL3}
N 9150 840 9150 940 {lab=WL3}
N 9240 740 9170 740 {lab=BL29}
N 9320 740 9390 740 {lab=BLB29}
C {sram512_bitcell.sym} 9600 840 0 0 {name=xr3c30}
N 9500 840 9470 840 {lab=WL3}
N 9470 840 9470 940 {lab=WL3}
N 9560 740 9490 740 {lab=BL30}
N 9640 740 9710 740 {lab=BLB30}
C {sram512_bitcell.sym} 9920 840 0 0 {name=xr3c31}
N 9820 840 9790 840 {lab=WL3}
N 9790 840 9790 940 {lab=WL3}
N 9880 740 9810 740 {lab=BL31}
N 9960 740 10030 740 {lab=BLB31}
N -300 940 9790 940 {lab=WL3}
C {devices/ipin.sym} -300 940 0 0 {name=pWL3 lab=WL3}
C {sram512_bitcell.sym} 0 1120 0 0 {name=xr4c0}
N -100 1120 -130 1120 {lab=WL4}
N -130 1120 -130 1220 {lab=WL4}
N -40 1020 -110 1020 {lab=BL0}
N 40 1020 110 1020 {lab=BLB0}
C {sram512_bitcell.sym} 320 1120 0 0 {name=xr4c1}
N 220 1120 190 1120 {lab=WL4}
N 190 1120 190 1220 {lab=WL4}
N 280 1020 210 1020 {lab=BL1}
N 360 1020 430 1020 {lab=BLB1}
C {sram512_bitcell.sym} 640 1120 0 0 {name=xr4c2}
N 540 1120 510 1120 {lab=WL4}
N 510 1120 510 1220 {lab=WL4}
N 600 1020 530 1020 {lab=BL2}
N 680 1020 750 1020 {lab=BLB2}
C {sram512_bitcell.sym} 960 1120 0 0 {name=xr4c3}
N 860 1120 830 1120 {lab=WL4}
N 830 1120 830 1220 {lab=WL4}
N 920 1020 850 1020 {lab=BL3}
N 1000 1020 1070 1020 {lab=BLB3}
C {sram512_bitcell.sym} 1280 1120 0 0 {name=xr4c4}
N 1180 1120 1150 1120 {lab=WL4}
N 1150 1120 1150 1220 {lab=WL4}
N 1240 1020 1170 1020 {lab=BL4}
N 1320 1020 1390 1020 {lab=BLB4}
C {sram512_bitcell.sym} 1600 1120 0 0 {name=xr4c5}
N 1500 1120 1470 1120 {lab=WL4}
N 1470 1120 1470 1220 {lab=WL4}
N 1560 1020 1490 1020 {lab=BL5}
N 1640 1020 1710 1020 {lab=BLB5}
C {sram512_bitcell.sym} 1920 1120 0 0 {name=xr4c6}
N 1820 1120 1790 1120 {lab=WL4}
N 1790 1120 1790 1220 {lab=WL4}
N 1880 1020 1810 1020 {lab=BL6}
N 1960 1020 2030 1020 {lab=BLB6}
C {sram512_bitcell.sym} 2240 1120 0 0 {name=xr4c7}
N 2140 1120 2110 1120 {lab=WL4}
N 2110 1120 2110 1220 {lab=WL4}
N 2200 1020 2130 1020 {lab=BL7}
N 2280 1020 2350 1020 {lab=BLB7}
C {sram512_bitcell.sym} 2560 1120 0 0 {name=xr4c8}
N 2460 1120 2430 1120 {lab=WL4}
N 2430 1120 2430 1220 {lab=WL4}
N 2520 1020 2450 1020 {lab=BL8}
N 2600 1020 2670 1020 {lab=BLB8}
C {sram512_bitcell.sym} 2880 1120 0 0 {name=xr4c9}
N 2780 1120 2750 1120 {lab=WL4}
N 2750 1120 2750 1220 {lab=WL4}
N 2840 1020 2770 1020 {lab=BL9}
N 2920 1020 2990 1020 {lab=BLB9}
C {sram512_bitcell.sym} 3200 1120 0 0 {name=xr4c10}
N 3100 1120 3070 1120 {lab=WL4}
N 3070 1120 3070 1220 {lab=WL4}
N 3160 1020 3090 1020 {lab=BL10}
N 3240 1020 3310 1020 {lab=BLB10}
C {sram512_bitcell.sym} 3520 1120 0 0 {name=xr4c11}
N 3420 1120 3390 1120 {lab=WL4}
N 3390 1120 3390 1220 {lab=WL4}
N 3480 1020 3410 1020 {lab=BL11}
N 3560 1020 3630 1020 {lab=BLB11}
C {sram512_bitcell.sym} 3840 1120 0 0 {name=xr4c12}
N 3740 1120 3710 1120 {lab=WL4}
N 3710 1120 3710 1220 {lab=WL4}
N 3800 1020 3730 1020 {lab=BL12}
N 3880 1020 3950 1020 {lab=BLB12}
C {sram512_bitcell.sym} 4160 1120 0 0 {name=xr4c13}
N 4060 1120 4030 1120 {lab=WL4}
N 4030 1120 4030 1220 {lab=WL4}
N 4120 1020 4050 1020 {lab=BL13}
N 4200 1020 4270 1020 {lab=BLB13}
C {sram512_bitcell.sym} 4480 1120 0 0 {name=xr4c14}
N 4380 1120 4350 1120 {lab=WL4}
N 4350 1120 4350 1220 {lab=WL4}
N 4440 1020 4370 1020 {lab=BL14}
N 4520 1020 4590 1020 {lab=BLB14}
C {sram512_bitcell.sym} 4800 1120 0 0 {name=xr4c15}
N 4700 1120 4670 1120 {lab=WL4}
N 4670 1120 4670 1220 {lab=WL4}
N 4760 1020 4690 1020 {lab=BL15}
N 4840 1020 4910 1020 {lab=BLB15}
C {sram512_bitcell.sym} 5120 1120 0 0 {name=xr4c16}
N 5020 1120 4990 1120 {lab=WL4}
N 4990 1120 4990 1220 {lab=WL4}
N 5080 1020 5010 1020 {lab=BL16}
N 5160 1020 5230 1020 {lab=BLB16}
C {sram512_bitcell.sym} 5440 1120 0 0 {name=xr4c17}
N 5340 1120 5310 1120 {lab=WL4}
N 5310 1120 5310 1220 {lab=WL4}
N 5400 1020 5330 1020 {lab=BL17}
N 5480 1020 5550 1020 {lab=BLB17}
C {sram512_bitcell.sym} 5760 1120 0 0 {name=xr4c18}
N 5660 1120 5630 1120 {lab=WL4}
N 5630 1120 5630 1220 {lab=WL4}
N 5720 1020 5650 1020 {lab=BL18}
N 5800 1020 5870 1020 {lab=BLB18}
C {sram512_bitcell.sym} 6080 1120 0 0 {name=xr4c19}
N 5980 1120 5950 1120 {lab=WL4}
N 5950 1120 5950 1220 {lab=WL4}
N 6040 1020 5970 1020 {lab=BL19}
N 6120 1020 6190 1020 {lab=BLB19}
C {sram512_bitcell.sym} 6400 1120 0 0 {name=xr4c20}
N 6300 1120 6270 1120 {lab=WL4}
N 6270 1120 6270 1220 {lab=WL4}
N 6360 1020 6290 1020 {lab=BL20}
N 6440 1020 6510 1020 {lab=BLB20}
C {sram512_bitcell.sym} 6720 1120 0 0 {name=xr4c21}
N 6620 1120 6590 1120 {lab=WL4}
N 6590 1120 6590 1220 {lab=WL4}
N 6680 1020 6610 1020 {lab=BL21}
N 6760 1020 6830 1020 {lab=BLB21}
C {sram512_bitcell.sym} 7040 1120 0 0 {name=xr4c22}
N 6940 1120 6910 1120 {lab=WL4}
N 6910 1120 6910 1220 {lab=WL4}
N 7000 1020 6930 1020 {lab=BL22}
N 7080 1020 7150 1020 {lab=BLB22}
C {sram512_bitcell.sym} 7360 1120 0 0 {name=xr4c23}
N 7260 1120 7230 1120 {lab=WL4}
N 7230 1120 7230 1220 {lab=WL4}
N 7320 1020 7250 1020 {lab=BL23}
N 7400 1020 7470 1020 {lab=BLB23}
C {sram512_bitcell.sym} 7680 1120 0 0 {name=xr4c24}
N 7580 1120 7550 1120 {lab=WL4}
N 7550 1120 7550 1220 {lab=WL4}
N 7640 1020 7570 1020 {lab=BL24}
N 7720 1020 7790 1020 {lab=BLB24}
C {sram512_bitcell.sym} 8000 1120 0 0 {name=xr4c25}
N 7900 1120 7870 1120 {lab=WL4}
N 7870 1120 7870 1220 {lab=WL4}
N 7960 1020 7890 1020 {lab=BL25}
N 8040 1020 8110 1020 {lab=BLB25}
C {sram512_bitcell.sym} 8320 1120 0 0 {name=xr4c26}
N 8220 1120 8190 1120 {lab=WL4}
N 8190 1120 8190 1220 {lab=WL4}
N 8280 1020 8210 1020 {lab=BL26}
N 8360 1020 8430 1020 {lab=BLB26}
C {sram512_bitcell.sym} 8640 1120 0 0 {name=xr4c27}
N 8540 1120 8510 1120 {lab=WL4}
N 8510 1120 8510 1220 {lab=WL4}
N 8600 1020 8530 1020 {lab=BL27}
N 8680 1020 8750 1020 {lab=BLB27}
C {sram512_bitcell.sym} 8960 1120 0 0 {name=xr4c28}
N 8860 1120 8830 1120 {lab=WL4}
N 8830 1120 8830 1220 {lab=WL4}
N 8920 1020 8850 1020 {lab=BL28}
N 9000 1020 9070 1020 {lab=BLB28}
C {sram512_bitcell.sym} 9280 1120 0 0 {name=xr4c29}
N 9180 1120 9150 1120 {lab=WL4}
N 9150 1120 9150 1220 {lab=WL4}
N 9240 1020 9170 1020 {lab=BL29}
N 9320 1020 9390 1020 {lab=BLB29}
C {sram512_bitcell.sym} 9600 1120 0 0 {name=xr4c30}
N 9500 1120 9470 1120 {lab=WL4}
N 9470 1120 9470 1220 {lab=WL4}
N 9560 1020 9490 1020 {lab=BL30}
N 9640 1020 9710 1020 {lab=BLB30}
C {sram512_bitcell.sym} 9920 1120 0 0 {name=xr4c31}
N 9820 1120 9790 1120 {lab=WL4}
N 9790 1120 9790 1220 {lab=WL4}
N 9880 1020 9810 1020 {lab=BL31}
N 9960 1020 10030 1020 {lab=BLB31}
N -300 1220 9790 1220 {lab=WL4}
C {devices/ipin.sym} -300 1220 0 0 {name=pWL4 lab=WL4}
C {sram512_bitcell.sym} 0 1400 0 0 {name=xr5c0}
N -100 1400 -130 1400 {lab=WL5}
N -130 1400 -130 1500 {lab=WL5}
N -40 1300 -110 1300 {lab=BL0}
N 40 1300 110 1300 {lab=BLB0}
C {sram512_bitcell.sym} 320 1400 0 0 {name=xr5c1}
N 220 1400 190 1400 {lab=WL5}
N 190 1400 190 1500 {lab=WL5}
N 280 1300 210 1300 {lab=BL1}
N 360 1300 430 1300 {lab=BLB1}
C {sram512_bitcell.sym} 640 1400 0 0 {name=xr5c2}
N 540 1400 510 1400 {lab=WL5}
N 510 1400 510 1500 {lab=WL5}
N 600 1300 530 1300 {lab=BL2}
N 680 1300 750 1300 {lab=BLB2}
C {sram512_bitcell.sym} 960 1400 0 0 {name=xr5c3}
N 860 1400 830 1400 {lab=WL5}
N 830 1400 830 1500 {lab=WL5}
N 920 1300 850 1300 {lab=BL3}
N 1000 1300 1070 1300 {lab=BLB3}
C {sram512_bitcell.sym} 1280 1400 0 0 {name=xr5c4}
N 1180 1400 1150 1400 {lab=WL5}
N 1150 1400 1150 1500 {lab=WL5}
N 1240 1300 1170 1300 {lab=BL4}
N 1320 1300 1390 1300 {lab=BLB4}
C {sram512_bitcell.sym} 1600 1400 0 0 {name=xr5c5}
N 1500 1400 1470 1400 {lab=WL5}
N 1470 1400 1470 1500 {lab=WL5}
N 1560 1300 1490 1300 {lab=BL5}
N 1640 1300 1710 1300 {lab=BLB5}
C {sram512_bitcell.sym} 1920 1400 0 0 {name=xr5c6}
N 1820 1400 1790 1400 {lab=WL5}
N 1790 1400 1790 1500 {lab=WL5}
N 1880 1300 1810 1300 {lab=BL6}
N 1960 1300 2030 1300 {lab=BLB6}
C {sram512_bitcell.sym} 2240 1400 0 0 {name=xr5c7}
N 2140 1400 2110 1400 {lab=WL5}
N 2110 1400 2110 1500 {lab=WL5}
N 2200 1300 2130 1300 {lab=BL7}
N 2280 1300 2350 1300 {lab=BLB7}
C {sram512_bitcell.sym} 2560 1400 0 0 {name=xr5c8}
N 2460 1400 2430 1400 {lab=WL5}
N 2430 1400 2430 1500 {lab=WL5}
N 2520 1300 2450 1300 {lab=BL8}
N 2600 1300 2670 1300 {lab=BLB8}
C {sram512_bitcell.sym} 2880 1400 0 0 {name=xr5c9}
N 2780 1400 2750 1400 {lab=WL5}
N 2750 1400 2750 1500 {lab=WL5}
N 2840 1300 2770 1300 {lab=BL9}
N 2920 1300 2990 1300 {lab=BLB9}
C {sram512_bitcell.sym} 3200 1400 0 0 {name=xr5c10}
N 3100 1400 3070 1400 {lab=WL5}
N 3070 1400 3070 1500 {lab=WL5}
N 3160 1300 3090 1300 {lab=BL10}
N 3240 1300 3310 1300 {lab=BLB10}
C {sram512_bitcell.sym} 3520 1400 0 0 {name=xr5c11}
N 3420 1400 3390 1400 {lab=WL5}
N 3390 1400 3390 1500 {lab=WL5}
N 3480 1300 3410 1300 {lab=BL11}
N 3560 1300 3630 1300 {lab=BLB11}
C {sram512_bitcell.sym} 3840 1400 0 0 {name=xr5c12}
N 3740 1400 3710 1400 {lab=WL5}
N 3710 1400 3710 1500 {lab=WL5}
N 3800 1300 3730 1300 {lab=BL12}
N 3880 1300 3950 1300 {lab=BLB12}
C {sram512_bitcell.sym} 4160 1400 0 0 {name=xr5c13}
N 4060 1400 4030 1400 {lab=WL5}
N 4030 1400 4030 1500 {lab=WL5}
N 4120 1300 4050 1300 {lab=BL13}
N 4200 1300 4270 1300 {lab=BLB13}
C {sram512_bitcell.sym} 4480 1400 0 0 {name=xr5c14}
N 4380 1400 4350 1400 {lab=WL5}
N 4350 1400 4350 1500 {lab=WL5}
N 4440 1300 4370 1300 {lab=BL14}
N 4520 1300 4590 1300 {lab=BLB14}
C {sram512_bitcell.sym} 4800 1400 0 0 {name=xr5c15}
N 4700 1400 4670 1400 {lab=WL5}
N 4670 1400 4670 1500 {lab=WL5}
N 4760 1300 4690 1300 {lab=BL15}
N 4840 1300 4910 1300 {lab=BLB15}
C {sram512_bitcell.sym} 5120 1400 0 0 {name=xr5c16}
N 5020 1400 4990 1400 {lab=WL5}
N 4990 1400 4990 1500 {lab=WL5}
N 5080 1300 5010 1300 {lab=BL16}
N 5160 1300 5230 1300 {lab=BLB16}
C {sram512_bitcell.sym} 5440 1400 0 0 {name=xr5c17}
N 5340 1400 5310 1400 {lab=WL5}
N 5310 1400 5310 1500 {lab=WL5}
N 5400 1300 5330 1300 {lab=BL17}
N 5480 1300 5550 1300 {lab=BLB17}
C {sram512_bitcell.sym} 5760 1400 0 0 {name=xr5c18}
N 5660 1400 5630 1400 {lab=WL5}
N 5630 1400 5630 1500 {lab=WL5}
N 5720 1300 5650 1300 {lab=BL18}
N 5800 1300 5870 1300 {lab=BLB18}
C {sram512_bitcell.sym} 6080 1400 0 0 {name=xr5c19}
N 5980 1400 5950 1400 {lab=WL5}
N 5950 1400 5950 1500 {lab=WL5}
N 6040 1300 5970 1300 {lab=BL19}
N 6120 1300 6190 1300 {lab=BLB19}
C {sram512_bitcell.sym} 6400 1400 0 0 {name=xr5c20}
N 6300 1400 6270 1400 {lab=WL5}
N 6270 1400 6270 1500 {lab=WL5}
N 6360 1300 6290 1300 {lab=BL20}
N 6440 1300 6510 1300 {lab=BLB20}
C {sram512_bitcell.sym} 6720 1400 0 0 {name=xr5c21}
N 6620 1400 6590 1400 {lab=WL5}
N 6590 1400 6590 1500 {lab=WL5}
N 6680 1300 6610 1300 {lab=BL21}
N 6760 1300 6830 1300 {lab=BLB21}
C {sram512_bitcell.sym} 7040 1400 0 0 {name=xr5c22}
N 6940 1400 6910 1400 {lab=WL5}
N 6910 1400 6910 1500 {lab=WL5}
N 7000 1300 6930 1300 {lab=BL22}
N 7080 1300 7150 1300 {lab=BLB22}
C {sram512_bitcell.sym} 7360 1400 0 0 {name=xr5c23}
N 7260 1400 7230 1400 {lab=WL5}
N 7230 1400 7230 1500 {lab=WL5}
N 7320 1300 7250 1300 {lab=BL23}
N 7400 1300 7470 1300 {lab=BLB23}
C {sram512_bitcell.sym} 7680 1400 0 0 {name=xr5c24}
N 7580 1400 7550 1400 {lab=WL5}
N 7550 1400 7550 1500 {lab=WL5}
N 7640 1300 7570 1300 {lab=BL24}
N 7720 1300 7790 1300 {lab=BLB24}
C {sram512_bitcell.sym} 8000 1400 0 0 {name=xr5c25}
N 7900 1400 7870 1400 {lab=WL5}
N 7870 1400 7870 1500 {lab=WL5}
N 7960 1300 7890 1300 {lab=BL25}
N 8040 1300 8110 1300 {lab=BLB25}
C {sram512_bitcell.sym} 8320 1400 0 0 {name=xr5c26}
N 8220 1400 8190 1400 {lab=WL5}
N 8190 1400 8190 1500 {lab=WL5}
N 8280 1300 8210 1300 {lab=BL26}
N 8360 1300 8430 1300 {lab=BLB26}
C {sram512_bitcell.sym} 8640 1400 0 0 {name=xr5c27}
N 8540 1400 8510 1400 {lab=WL5}
N 8510 1400 8510 1500 {lab=WL5}
N 8600 1300 8530 1300 {lab=BL27}
N 8680 1300 8750 1300 {lab=BLB27}
C {sram512_bitcell.sym} 8960 1400 0 0 {name=xr5c28}
N 8860 1400 8830 1400 {lab=WL5}
N 8830 1400 8830 1500 {lab=WL5}
N 8920 1300 8850 1300 {lab=BL28}
N 9000 1300 9070 1300 {lab=BLB28}
C {sram512_bitcell.sym} 9280 1400 0 0 {name=xr5c29}
N 9180 1400 9150 1400 {lab=WL5}
N 9150 1400 9150 1500 {lab=WL5}
N 9240 1300 9170 1300 {lab=BL29}
N 9320 1300 9390 1300 {lab=BLB29}
C {sram512_bitcell.sym} 9600 1400 0 0 {name=xr5c30}
N 9500 1400 9470 1400 {lab=WL5}
N 9470 1400 9470 1500 {lab=WL5}
N 9560 1300 9490 1300 {lab=BL30}
N 9640 1300 9710 1300 {lab=BLB30}
C {sram512_bitcell.sym} 9920 1400 0 0 {name=xr5c31}
N 9820 1400 9790 1400 {lab=WL5}
N 9790 1400 9790 1500 {lab=WL5}
N 9880 1300 9810 1300 {lab=BL31}
N 9960 1300 10030 1300 {lab=BLB31}
N -300 1500 9790 1500 {lab=WL5}
C {devices/ipin.sym} -300 1500 0 0 {name=pWL5 lab=WL5}
C {sram512_bitcell.sym} 0 1680 0 0 {name=xr6c0}
N -100 1680 -130 1680 {lab=WL6}
N -130 1680 -130 1780 {lab=WL6}
N -40 1580 -110 1580 {lab=BL0}
N 40 1580 110 1580 {lab=BLB0}
C {sram512_bitcell.sym} 320 1680 0 0 {name=xr6c1}
N 220 1680 190 1680 {lab=WL6}
N 190 1680 190 1780 {lab=WL6}
N 280 1580 210 1580 {lab=BL1}
N 360 1580 430 1580 {lab=BLB1}
C {sram512_bitcell.sym} 640 1680 0 0 {name=xr6c2}
N 540 1680 510 1680 {lab=WL6}
N 510 1680 510 1780 {lab=WL6}
N 600 1580 530 1580 {lab=BL2}
N 680 1580 750 1580 {lab=BLB2}
C {sram512_bitcell.sym} 960 1680 0 0 {name=xr6c3}
N 860 1680 830 1680 {lab=WL6}
N 830 1680 830 1780 {lab=WL6}
N 920 1580 850 1580 {lab=BL3}
N 1000 1580 1070 1580 {lab=BLB3}
C {sram512_bitcell.sym} 1280 1680 0 0 {name=xr6c4}
N 1180 1680 1150 1680 {lab=WL6}
N 1150 1680 1150 1780 {lab=WL6}
N 1240 1580 1170 1580 {lab=BL4}
N 1320 1580 1390 1580 {lab=BLB4}
C {sram512_bitcell.sym} 1600 1680 0 0 {name=xr6c5}
N 1500 1680 1470 1680 {lab=WL6}
N 1470 1680 1470 1780 {lab=WL6}
N 1560 1580 1490 1580 {lab=BL5}
N 1640 1580 1710 1580 {lab=BLB5}
C {sram512_bitcell.sym} 1920 1680 0 0 {name=xr6c6}
N 1820 1680 1790 1680 {lab=WL6}
N 1790 1680 1790 1780 {lab=WL6}
N 1880 1580 1810 1580 {lab=BL6}
N 1960 1580 2030 1580 {lab=BLB6}
C {sram512_bitcell.sym} 2240 1680 0 0 {name=xr6c7}
N 2140 1680 2110 1680 {lab=WL6}
N 2110 1680 2110 1780 {lab=WL6}
N 2200 1580 2130 1580 {lab=BL7}
N 2280 1580 2350 1580 {lab=BLB7}
C {sram512_bitcell.sym} 2560 1680 0 0 {name=xr6c8}
N 2460 1680 2430 1680 {lab=WL6}
N 2430 1680 2430 1780 {lab=WL6}
N 2520 1580 2450 1580 {lab=BL8}
N 2600 1580 2670 1580 {lab=BLB8}
C {sram512_bitcell.sym} 2880 1680 0 0 {name=xr6c9}
N 2780 1680 2750 1680 {lab=WL6}
N 2750 1680 2750 1780 {lab=WL6}
N 2840 1580 2770 1580 {lab=BL9}
N 2920 1580 2990 1580 {lab=BLB9}
C {sram512_bitcell.sym} 3200 1680 0 0 {name=xr6c10}
N 3100 1680 3070 1680 {lab=WL6}
N 3070 1680 3070 1780 {lab=WL6}
N 3160 1580 3090 1580 {lab=BL10}
N 3240 1580 3310 1580 {lab=BLB10}
C {sram512_bitcell.sym} 3520 1680 0 0 {name=xr6c11}
N 3420 1680 3390 1680 {lab=WL6}
N 3390 1680 3390 1780 {lab=WL6}
N 3480 1580 3410 1580 {lab=BL11}
N 3560 1580 3630 1580 {lab=BLB11}
C {sram512_bitcell.sym} 3840 1680 0 0 {name=xr6c12}
N 3740 1680 3710 1680 {lab=WL6}
N 3710 1680 3710 1780 {lab=WL6}
N 3800 1580 3730 1580 {lab=BL12}
N 3880 1580 3950 1580 {lab=BLB12}
C {sram512_bitcell.sym} 4160 1680 0 0 {name=xr6c13}
N 4060 1680 4030 1680 {lab=WL6}
N 4030 1680 4030 1780 {lab=WL6}
N 4120 1580 4050 1580 {lab=BL13}
N 4200 1580 4270 1580 {lab=BLB13}
C {sram512_bitcell.sym} 4480 1680 0 0 {name=xr6c14}
N 4380 1680 4350 1680 {lab=WL6}
N 4350 1680 4350 1780 {lab=WL6}
N 4440 1580 4370 1580 {lab=BL14}
N 4520 1580 4590 1580 {lab=BLB14}
C {sram512_bitcell.sym} 4800 1680 0 0 {name=xr6c15}
N 4700 1680 4670 1680 {lab=WL6}
N 4670 1680 4670 1780 {lab=WL6}
N 4760 1580 4690 1580 {lab=BL15}
N 4840 1580 4910 1580 {lab=BLB15}
C {sram512_bitcell.sym} 5120 1680 0 0 {name=xr6c16}
N 5020 1680 4990 1680 {lab=WL6}
N 4990 1680 4990 1780 {lab=WL6}
N 5080 1580 5010 1580 {lab=BL16}
N 5160 1580 5230 1580 {lab=BLB16}
C {sram512_bitcell.sym} 5440 1680 0 0 {name=xr6c17}
N 5340 1680 5310 1680 {lab=WL6}
N 5310 1680 5310 1780 {lab=WL6}
N 5400 1580 5330 1580 {lab=BL17}
N 5480 1580 5550 1580 {lab=BLB17}
C {sram512_bitcell.sym} 5760 1680 0 0 {name=xr6c18}
N 5660 1680 5630 1680 {lab=WL6}
N 5630 1680 5630 1780 {lab=WL6}
N 5720 1580 5650 1580 {lab=BL18}
N 5800 1580 5870 1580 {lab=BLB18}
C {sram512_bitcell.sym} 6080 1680 0 0 {name=xr6c19}
N 5980 1680 5950 1680 {lab=WL6}
N 5950 1680 5950 1780 {lab=WL6}
N 6040 1580 5970 1580 {lab=BL19}
N 6120 1580 6190 1580 {lab=BLB19}
C {sram512_bitcell.sym} 6400 1680 0 0 {name=xr6c20}
N 6300 1680 6270 1680 {lab=WL6}
N 6270 1680 6270 1780 {lab=WL6}
N 6360 1580 6290 1580 {lab=BL20}
N 6440 1580 6510 1580 {lab=BLB20}
C {sram512_bitcell.sym} 6720 1680 0 0 {name=xr6c21}
N 6620 1680 6590 1680 {lab=WL6}
N 6590 1680 6590 1780 {lab=WL6}
N 6680 1580 6610 1580 {lab=BL21}
N 6760 1580 6830 1580 {lab=BLB21}
C {sram512_bitcell.sym} 7040 1680 0 0 {name=xr6c22}
N 6940 1680 6910 1680 {lab=WL6}
N 6910 1680 6910 1780 {lab=WL6}
N 7000 1580 6930 1580 {lab=BL22}
N 7080 1580 7150 1580 {lab=BLB22}
C {sram512_bitcell.sym} 7360 1680 0 0 {name=xr6c23}
N 7260 1680 7230 1680 {lab=WL6}
N 7230 1680 7230 1780 {lab=WL6}
N 7320 1580 7250 1580 {lab=BL23}
N 7400 1580 7470 1580 {lab=BLB23}
C {sram512_bitcell.sym} 7680 1680 0 0 {name=xr6c24}
N 7580 1680 7550 1680 {lab=WL6}
N 7550 1680 7550 1780 {lab=WL6}
N 7640 1580 7570 1580 {lab=BL24}
N 7720 1580 7790 1580 {lab=BLB24}
C {sram512_bitcell.sym} 8000 1680 0 0 {name=xr6c25}
N 7900 1680 7870 1680 {lab=WL6}
N 7870 1680 7870 1780 {lab=WL6}
N 7960 1580 7890 1580 {lab=BL25}
N 8040 1580 8110 1580 {lab=BLB25}
C {sram512_bitcell.sym} 8320 1680 0 0 {name=xr6c26}
N 8220 1680 8190 1680 {lab=WL6}
N 8190 1680 8190 1780 {lab=WL6}
N 8280 1580 8210 1580 {lab=BL26}
N 8360 1580 8430 1580 {lab=BLB26}
C {sram512_bitcell.sym} 8640 1680 0 0 {name=xr6c27}
N 8540 1680 8510 1680 {lab=WL6}
N 8510 1680 8510 1780 {lab=WL6}
N 8600 1580 8530 1580 {lab=BL27}
N 8680 1580 8750 1580 {lab=BLB27}
C {sram512_bitcell.sym} 8960 1680 0 0 {name=xr6c28}
N 8860 1680 8830 1680 {lab=WL6}
N 8830 1680 8830 1780 {lab=WL6}
N 8920 1580 8850 1580 {lab=BL28}
N 9000 1580 9070 1580 {lab=BLB28}
C {sram512_bitcell.sym} 9280 1680 0 0 {name=xr6c29}
N 9180 1680 9150 1680 {lab=WL6}
N 9150 1680 9150 1780 {lab=WL6}
N 9240 1580 9170 1580 {lab=BL29}
N 9320 1580 9390 1580 {lab=BLB29}
C {sram512_bitcell.sym} 9600 1680 0 0 {name=xr6c30}
N 9500 1680 9470 1680 {lab=WL6}
N 9470 1680 9470 1780 {lab=WL6}
N 9560 1580 9490 1580 {lab=BL30}
N 9640 1580 9710 1580 {lab=BLB30}
C {sram512_bitcell.sym} 9920 1680 0 0 {name=xr6c31}
N 9820 1680 9790 1680 {lab=WL6}
N 9790 1680 9790 1780 {lab=WL6}
N 9880 1580 9810 1580 {lab=BL31}
N 9960 1580 10030 1580 {lab=BLB31}
N -300 1780 9790 1780 {lab=WL6}
C {devices/ipin.sym} -300 1780 0 0 {name=pWL6 lab=WL6}
C {sram512_bitcell.sym} 0 1960 0 0 {name=xr7c0}
N -100 1960 -130 1960 {lab=WL7}
N -130 1960 -130 2060 {lab=WL7}
N -40 1860 -110 1860 {lab=BL0}
N 40 1860 110 1860 {lab=BLB0}
C {sram512_bitcell.sym} 320 1960 0 0 {name=xr7c1}
N 220 1960 190 1960 {lab=WL7}
N 190 1960 190 2060 {lab=WL7}
N 280 1860 210 1860 {lab=BL1}
N 360 1860 430 1860 {lab=BLB1}
C {sram512_bitcell.sym} 640 1960 0 0 {name=xr7c2}
N 540 1960 510 1960 {lab=WL7}
N 510 1960 510 2060 {lab=WL7}
N 600 1860 530 1860 {lab=BL2}
N 680 1860 750 1860 {lab=BLB2}
C {sram512_bitcell.sym} 960 1960 0 0 {name=xr7c3}
N 860 1960 830 1960 {lab=WL7}
N 830 1960 830 2060 {lab=WL7}
N 920 1860 850 1860 {lab=BL3}
N 1000 1860 1070 1860 {lab=BLB3}
C {sram512_bitcell.sym} 1280 1960 0 0 {name=xr7c4}
N 1180 1960 1150 1960 {lab=WL7}
N 1150 1960 1150 2060 {lab=WL7}
N 1240 1860 1170 1860 {lab=BL4}
N 1320 1860 1390 1860 {lab=BLB4}
C {sram512_bitcell.sym} 1600 1960 0 0 {name=xr7c5}
N 1500 1960 1470 1960 {lab=WL7}
N 1470 1960 1470 2060 {lab=WL7}
N 1560 1860 1490 1860 {lab=BL5}
N 1640 1860 1710 1860 {lab=BLB5}
C {sram512_bitcell.sym} 1920 1960 0 0 {name=xr7c6}
N 1820 1960 1790 1960 {lab=WL7}
N 1790 1960 1790 2060 {lab=WL7}
N 1880 1860 1810 1860 {lab=BL6}
N 1960 1860 2030 1860 {lab=BLB6}
C {sram512_bitcell.sym} 2240 1960 0 0 {name=xr7c7}
N 2140 1960 2110 1960 {lab=WL7}
N 2110 1960 2110 2060 {lab=WL7}
N 2200 1860 2130 1860 {lab=BL7}
N 2280 1860 2350 1860 {lab=BLB7}
C {sram512_bitcell.sym} 2560 1960 0 0 {name=xr7c8}
N 2460 1960 2430 1960 {lab=WL7}
N 2430 1960 2430 2060 {lab=WL7}
N 2520 1860 2450 1860 {lab=BL8}
N 2600 1860 2670 1860 {lab=BLB8}
C {sram512_bitcell.sym} 2880 1960 0 0 {name=xr7c9}
N 2780 1960 2750 1960 {lab=WL7}
N 2750 1960 2750 2060 {lab=WL7}
N 2840 1860 2770 1860 {lab=BL9}
N 2920 1860 2990 1860 {lab=BLB9}
C {sram512_bitcell.sym} 3200 1960 0 0 {name=xr7c10}
N 3100 1960 3070 1960 {lab=WL7}
N 3070 1960 3070 2060 {lab=WL7}
N 3160 1860 3090 1860 {lab=BL10}
N 3240 1860 3310 1860 {lab=BLB10}
C {sram512_bitcell.sym} 3520 1960 0 0 {name=xr7c11}
N 3420 1960 3390 1960 {lab=WL7}
N 3390 1960 3390 2060 {lab=WL7}
N 3480 1860 3410 1860 {lab=BL11}
N 3560 1860 3630 1860 {lab=BLB11}
C {sram512_bitcell.sym} 3840 1960 0 0 {name=xr7c12}
N 3740 1960 3710 1960 {lab=WL7}
N 3710 1960 3710 2060 {lab=WL7}
N 3800 1860 3730 1860 {lab=BL12}
N 3880 1860 3950 1860 {lab=BLB12}
C {sram512_bitcell.sym} 4160 1960 0 0 {name=xr7c13}
N 4060 1960 4030 1960 {lab=WL7}
N 4030 1960 4030 2060 {lab=WL7}
N 4120 1860 4050 1860 {lab=BL13}
N 4200 1860 4270 1860 {lab=BLB13}
C {sram512_bitcell.sym} 4480 1960 0 0 {name=xr7c14}
N 4380 1960 4350 1960 {lab=WL7}
N 4350 1960 4350 2060 {lab=WL7}
N 4440 1860 4370 1860 {lab=BL14}
N 4520 1860 4590 1860 {lab=BLB14}
C {sram512_bitcell.sym} 4800 1960 0 0 {name=xr7c15}
N 4700 1960 4670 1960 {lab=WL7}
N 4670 1960 4670 2060 {lab=WL7}
N 4760 1860 4690 1860 {lab=BL15}
N 4840 1860 4910 1860 {lab=BLB15}
C {sram512_bitcell.sym} 5120 1960 0 0 {name=xr7c16}
N 5020 1960 4990 1960 {lab=WL7}
N 4990 1960 4990 2060 {lab=WL7}
N 5080 1860 5010 1860 {lab=BL16}
N 5160 1860 5230 1860 {lab=BLB16}
C {sram512_bitcell.sym} 5440 1960 0 0 {name=xr7c17}
N 5340 1960 5310 1960 {lab=WL7}
N 5310 1960 5310 2060 {lab=WL7}
N 5400 1860 5330 1860 {lab=BL17}
N 5480 1860 5550 1860 {lab=BLB17}
C {sram512_bitcell.sym} 5760 1960 0 0 {name=xr7c18}
N 5660 1960 5630 1960 {lab=WL7}
N 5630 1960 5630 2060 {lab=WL7}
N 5720 1860 5650 1860 {lab=BL18}
N 5800 1860 5870 1860 {lab=BLB18}
C {sram512_bitcell.sym} 6080 1960 0 0 {name=xr7c19}
N 5980 1960 5950 1960 {lab=WL7}
N 5950 1960 5950 2060 {lab=WL7}
N 6040 1860 5970 1860 {lab=BL19}
N 6120 1860 6190 1860 {lab=BLB19}
C {sram512_bitcell.sym} 6400 1960 0 0 {name=xr7c20}
N 6300 1960 6270 1960 {lab=WL7}
N 6270 1960 6270 2060 {lab=WL7}
N 6360 1860 6290 1860 {lab=BL20}
N 6440 1860 6510 1860 {lab=BLB20}
C {sram512_bitcell.sym} 6720 1960 0 0 {name=xr7c21}
N 6620 1960 6590 1960 {lab=WL7}
N 6590 1960 6590 2060 {lab=WL7}
N 6680 1860 6610 1860 {lab=BL21}
N 6760 1860 6830 1860 {lab=BLB21}
C {sram512_bitcell.sym} 7040 1960 0 0 {name=xr7c22}
N 6940 1960 6910 1960 {lab=WL7}
N 6910 1960 6910 2060 {lab=WL7}
N 7000 1860 6930 1860 {lab=BL22}
N 7080 1860 7150 1860 {lab=BLB22}
C {sram512_bitcell.sym} 7360 1960 0 0 {name=xr7c23}
N 7260 1960 7230 1960 {lab=WL7}
N 7230 1960 7230 2060 {lab=WL7}
N 7320 1860 7250 1860 {lab=BL23}
N 7400 1860 7470 1860 {lab=BLB23}
C {sram512_bitcell.sym} 7680 1960 0 0 {name=xr7c24}
N 7580 1960 7550 1960 {lab=WL7}
N 7550 1960 7550 2060 {lab=WL7}
N 7640 1860 7570 1860 {lab=BL24}
N 7720 1860 7790 1860 {lab=BLB24}
C {sram512_bitcell.sym} 8000 1960 0 0 {name=xr7c25}
N 7900 1960 7870 1960 {lab=WL7}
N 7870 1960 7870 2060 {lab=WL7}
N 7960 1860 7890 1860 {lab=BL25}
N 8040 1860 8110 1860 {lab=BLB25}
C {sram512_bitcell.sym} 8320 1960 0 0 {name=xr7c26}
N 8220 1960 8190 1960 {lab=WL7}
N 8190 1960 8190 2060 {lab=WL7}
N 8280 1860 8210 1860 {lab=BL26}
N 8360 1860 8430 1860 {lab=BLB26}
C {sram512_bitcell.sym} 8640 1960 0 0 {name=xr7c27}
N 8540 1960 8510 1960 {lab=WL7}
N 8510 1960 8510 2060 {lab=WL7}
N 8600 1860 8530 1860 {lab=BL27}
N 8680 1860 8750 1860 {lab=BLB27}
C {sram512_bitcell.sym} 8960 1960 0 0 {name=xr7c28}
N 8860 1960 8830 1960 {lab=WL7}
N 8830 1960 8830 2060 {lab=WL7}
N 8920 1860 8850 1860 {lab=BL28}
N 9000 1860 9070 1860 {lab=BLB28}
C {sram512_bitcell.sym} 9280 1960 0 0 {name=xr7c29}
N 9180 1960 9150 1960 {lab=WL7}
N 9150 1960 9150 2060 {lab=WL7}
N 9240 1860 9170 1860 {lab=BL29}
N 9320 1860 9390 1860 {lab=BLB29}
C {sram512_bitcell.sym} 9600 1960 0 0 {name=xr7c30}
N 9500 1960 9470 1960 {lab=WL7}
N 9470 1960 9470 2060 {lab=WL7}
N 9560 1860 9490 1860 {lab=BL30}
N 9640 1860 9710 1860 {lab=BLB30}
C {sram512_bitcell.sym} 9920 1960 0 0 {name=xr7c31}
N 9820 1960 9790 1960 {lab=WL7}
N 9790 1960 9790 2060 {lab=WL7}
N 9880 1860 9810 1860 {lab=BL31}
N 9960 1860 10030 1860 {lab=BLB31}
N -300 2060 9790 2060 {lab=WL7}
C {devices/ipin.sym} -300 2060 0 0 {name=pWL7 lab=WL7}
C {sram512_bitcell.sym} 0 2240 0 0 {name=xr8c0}
N -100 2240 -130 2240 {lab=WL8}
N -130 2240 -130 2340 {lab=WL8}
N -40 2140 -110 2140 {lab=BL0}
N 40 2140 110 2140 {lab=BLB0}
C {sram512_bitcell.sym} 320 2240 0 0 {name=xr8c1}
N 220 2240 190 2240 {lab=WL8}
N 190 2240 190 2340 {lab=WL8}
N 280 2140 210 2140 {lab=BL1}
N 360 2140 430 2140 {lab=BLB1}
C {sram512_bitcell.sym} 640 2240 0 0 {name=xr8c2}
N 540 2240 510 2240 {lab=WL8}
N 510 2240 510 2340 {lab=WL8}
N 600 2140 530 2140 {lab=BL2}
N 680 2140 750 2140 {lab=BLB2}
C {sram512_bitcell.sym} 960 2240 0 0 {name=xr8c3}
N 860 2240 830 2240 {lab=WL8}
N 830 2240 830 2340 {lab=WL8}
N 920 2140 850 2140 {lab=BL3}
N 1000 2140 1070 2140 {lab=BLB3}
C {sram512_bitcell.sym} 1280 2240 0 0 {name=xr8c4}
N 1180 2240 1150 2240 {lab=WL8}
N 1150 2240 1150 2340 {lab=WL8}
N 1240 2140 1170 2140 {lab=BL4}
N 1320 2140 1390 2140 {lab=BLB4}
C {sram512_bitcell.sym} 1600 2240 0 0 {name=xr8c5}
N 1500 2240 1470 2240 {lab=WL8}
N 1470 2240 1470 2340 {lab=WL8}
N 1560 2140 1490 2140 {lab=BL5}
N 1640 2140 1710 2140 {lab=BLB5}
C {sram512_bitcell.sym} 1920 2240 0 0 {name=xr8c6}
N 1820 2240 1790 2240 {lab=WL8}
N 1790 2240 1790 2340 {lab=WL8}
N 1880 2140 1810 2140 {lab=BL6}
N 1960 2140 2030 2140 {lab=BLB6}
C {sram512_bitcell.sym} 2240 2240 0 0 {name=xr8c7}
N 2140 2240 2110 2240 {lab=WL8}
N 2110 2240 2110 2340 {lab=WL8}
N 2200 2140 2130 2140 {lab=BL7}
N 2280 2140 2350 2140 {lab=BLB7}
C {sram512_bitcell.sym} 2560 2240 0 0 {name=xr8c8}
N 2460 2240 2430 2240 {lab=WL8}
N 2430 2240 2430 2340 {lab=WL8}
N 2520 2140 2450 2140 {lab=BL8}
N 2600 2140 2670 2140 {lab=BLB8}
C {sram512_bitcell.sym} 2880 2240 0 0 {name=xr8c9}
N 2780 2240 2750 2240 {lab=WL8}
N 2750 2240 2750 2340 {lab=WL8}
N 2840 2140 2770 2140 {lab=BL9}
N 2920 2140 2990 2140 {lab=BLB9}
C {sram512_bitcell.sym} 3200 2240 0 0 {name=xr8c10}
N 3100 2240 3070 2240 {lab=WL8}
N 3070 2240 3070 2340 {lab=WL8}
N 3160 2140 3090 2140 {lab=BL10}
N 3240 2140 3310 2140 {lab=BLB10}
C {sram512_bitcell.sym} 3520 2240 0 0 {name=xr8c11}
N 3420 2240 3390 2240 {lab=WL8}
N 3390 2240 3390 2340 {lab=WL8}
N 3480 2140 3410 2140 {lab=BL11}
N 3560 2140 3630 2140 {lab=BLB11}
C {sram512_bitcell.sym} 3840 2240 0 0 {name=xr8c12}
N 3740 2240 3710 2240 {lab=WL8}
N 3710 2240 3710 2340 {lab=WL8}
N 3800 2140 3730 2140 {lab=BL12}
N 3880 2140 3950 2140 {lab=BLB12}
C {sram512_bitcell.sym} 4160 2240 0 0 {name=xr8c13}
N 4060 2240 4030 2240 {lab=WL8}
N 4030 2240 4030 2340 {lab=WL8}
N 4120 2140 4050 2140 {lab=BL13}
N 4200 2140 4270 2140 {lab=BLB13}
C {sram512_bitcell.sym} 4480 2240 0 0 {name=xr8c14}
N 4380 2240 4350 2240 {lab=WL8}
N 4350 2240 4350 2340 {lab=WL8}
N 4440 2140 4370 2140 {lab=BL14}
N 4520 2140 4590 2140 {lab=BLB14}
C {sram512_bitcell.sym} 4800 2240 0 0 {name=xr8c15}
N 4700 2240 4670 2240 {lab=WL8}
N 4670 2240 4670 2340 {lab=WL8}
N 4760 2140 4690 2140 {lab=BL15}
N 4840 2140 4910 2140 {lab=BLB15}
C {sram512_bitcell.sym} 5120 2240 0 0 {name=xr8c16}
N 5020 2240 4990 2240 {lab=WL8}
N 4990 2240 4990 2340 {lab=WL8}
N 5080 2140 5010 2140 {lab=BL16}
N 5160 2140 5230 2140 {lab=BLB16}
C {sram512_bitcell.sym} 5440 2240 0 0 {name=xr8c17}
N 5340 2240 5310 2240 {lab=WL8}
N 5310 2240 5310 2340 {lab=WL8}
N 5400 2140 5330 2140 {lab=BL17}
N 5480 2140 5550 2140 {lab=BLB17}
C {sram512_bitcell.sym} 5760 2240 0 0 {name=xr8c18}
N 5660 2240 5630 2240 {lab=WL8}
N 5630 2240 5630 2340 {lab=WL8}
N 5720 2140 5650 2140 {lab=BL18}
N 5800 2140 5870 2140 {lab=BLB18}
C {sram512_bitcell.sym} 6080 2240 0 0 {name=xr8c19}
N 5980 2240 5950 2240 {lab=WL8}
N 5950 2240 5950 2340 {lab=WL8}
N 6040 2140 5970 2140 {lab=BL19}
N 6120 2140 6190 2140 {lab=BLB19}
C {sram512_bitcell.sym} 6400 2240 0 0 {name=xr8c20}
N 6300 2240 6270 2240 {lab=WL8}
N 6270 2240 6270 2340 {lab=WL8}
N 6360 2140 6290 2140 {lab=BL20}
N 6440 2140 6510 2140 {lab=BLB20}
C {sram512_bitcell.sym} 6720 2240 0 0 {name=xr8c21}
N 6620 2240 6590 2240 {lab=WL8}
N 6590 2240 6590 2340 {lab=WL8}
N 6680 2140 6610 2140 {lab=BL21}
N 6760 2140 6830 2140 {lab=BLB21}
C {sram512_bitcell.sym} 7040 2240 0 0 {name=xr8c22}
N 6940 2240 6910 2240 {lab=WL8}
N 6910 2240 6910 2340 {lab=WL8}
N 7000 2140 6930 2140 {lab=BL22}
N 7080 2140 7150 2140 {lab=BLB22}
C {sram512_bitcell.sym} 7360 2240 0 0 {name=xr8c23}
N 7260 2240 7230 2240 {lab=WL8}
N 7230 2240 7230 2340 {lab=WL8}
N 7320 2140 7250 2140 {lab=BL23}
N 7400 2140 7470 2140 {lab=BLB23}
C {sram512_bitcell.sym} 7680 2240 0 0 {name=xr8c24}
N 7580 2240 7550 2240 {lab=WL8}
N 7550 2240 7550 2340 {lab=WL8}
N 7640 2140 7570 2140 {lab=BL24}
N 7720 2140 7790 2140 {lab=BLB24}
C {sram512_bitcell.sym} 8000 2240 0 0 {name=xr8c25}
N 7900 2240 7870 2240 {lab=WL8}
N 7870 2240 7870 2340 {lab=WL8}
N 7960 2140 7890 2140 {lab=BL25}
N 8040 2140 8110 2140 {lab=BLB25}
C {sram512_bitcell.sym} 8320 2240 0 0 {name=xr8c26}
N 8220 2240 8190 2240 {lab=WL8}
N 8190 2240 8190 2340 {lab=WL8}
N 8280 2140 8210 2140 {lab=BL26}
N 8360 2140 8430 2140 {lab=BLB26}
C {sram512_bitcell.sym} 8640 2240 0 0 {name=xr8c27}
N 8540 2240 8510 2240 {lab=WL8}
N 8510 2240 8510 2340 {lab=WL8}
N 8600 2140 8530 2140 {lab=BL27}
N 8680 2140 8750 2140 {lab=BLB27}
C {sram512_bitcell.sym} 8960 2240 0 0 {name=xr8c28}
N 8860 2240 8830 2240 {lab=WL8}
N 8830 2240 8830 2340 {lab=WL8}
N 8920 2140 8850 2140 {lab=BL28}
N 9000 2140 9070 2140 {lab=BLB28}
C {sram512_bitcell.sym} 9280 2240 0 0 {name=xr8c29}
N 9180 2240 9150 2240 {lab=WL8}
N 9150 2240 9150 2340 {lab=WL8}
N 9240 2140 9170 2140 {lab=BL29}
N 9320 2140 9390 2140 {lab=BLB29}
C {sram512_bitcell.sym} 9600 2240 0 0 {name=xr8c30}
N 9500 2240 9470 2240 {lab=WL8}
N 9470 2240 9470 2340 {lab=WL8}
N 9560 2140 9490 2140 {lab=BL30}
N 9640 2140 9710 2140 {lab=BLB30}
C {sram512_bitcell.sym} 9920 2240 0 0 {name=xr8c31}
N 9820 2240 9790 2240 {lab=WL8}
N 9790 2240 9790 2340 {lab=WL8}
N 9880 2140 9810 2140 {lab=BL31}
N 9960 2140 10030 2140 {lab=BLB31}
N -300 2340 9790 2340 {lab=WL8}
C {devices/ipin.sym} -300 2340 0 0 {name=pWL8 lab=WL8}
C {sram512_bitcell.sym} 0 2520 0 0 {name=xr9c0}
N -100 2520 -130 2520 {lab=WL9}
N -130 2520 -130 2620 {lab=WL9}
N -40 2420 -110 2420 {lab=BL0}
N 40 2420 110 2420 {lab=BLB0}
C {sram512_bitcell.sym} 320 2520 0 0 {name=xr9c1}
N 220 2520 190 2520 {lab=WL9}
N 190 2520 190 2620 {lab=WL9}
N 280 2420 210 2420 {lab=BL1}
N 360 2420 430 2420 {lab=BLB1}
C {sram512_bitcell.sym} 640 2520 0 0 {name=xr9c2}
N 540 2520 510 2520 {lab=WL9}
N 510 2520 510 2620 {lab=WL9}
N 600 2420 530 2420 {lab=BL2}
N 680 2420 750 2420 {lab=BLB2}
C {sram512_bitcell.sym} 960 2520 0 0 {name=xr9c3}
N 860 2520 830 2520 {lab=WL9}
N 830 2520 830 2620 {lab=WL9}
N 920 2420 850 2420 {lab=BL3}
N 1000 2420 1070 2420 {lab=BLB3}
C {sram512_bitcell.sym} 1280 2520 0 0 {name=xr9c4}
N 1180 2520 1150 2520 {lab=WL9}
N 1150 2520 1150 2620 {lab=WL9}
N 1240 2420 1170 2420 {lab=BL4}
N 1320 2420 1390 2420 {lab=BLB4}
C {sram512_bitcell.sym} 1600 2520 0 0 {name=xr9c5}
N 1500 2520 1470 2520 {lab=WL9}
N 1470 2520 1470 2620 {lab=WL9}
N 1560 2420 1490 2420 {lab=BL5}
N 1640 2420 1710 2420 {lab=BLB5}
C {sram512_bitcell.sym} 1920 2520 0 0 {name=xr9c6}
N 1820 2520 1790 2520 {lab=WL9}
N 1790 2520 1790 2620 {lab=WL9}
N 1880 2420 1810 2420 {lab=BL6}
N 1960 2420 2030 2420 {lab=BLB6}
C {sram512_bitcell.sym} 2240 2520 0 0 {name=xr9c7}
N 2140 2520 2110 2520 {lab=WL9}
N 2110 2520 2110 2620 {lab=WL9}
N 2200 2420 2130 2420 {lab=BL7}
N 2280 2420 2350 2420 {lab=BLB7}
C {sram512_bitcell.sym} 2560 2520 0 0 {name=xr9c8}
N 2460 2520 2430 2520 {lab=WL9}
N 2430 2520 2430 2620 {lab=WL9}
N 2520 2420 2450 2420 {lab=BL8}
N 2600 2420 2670 2420 {lab=BLB8}
C {sram512_bitcell.sym} 2880 2520 0 0 {name=xr9c9}
N 2780 2520 2750 2520 {lab=WL9}
N 2750 2520 2750 2620 {lab=WL9}
N 2840 2420 2770 2420 {lab=BL9}
N 2920 2420 2990 2420 {lab=BLB9}
C {sram512_bitcell.sym} 3200 2520 0 0 {name=xr9c10}
N 3100 2520 3070 2520 {lab=WL9}
N 3070 2520 3070 2620 {lab=WL9}
N 3160 2420 3090 2420 {lab=BL10}
N 3240 2420 3310 2420 {lab=BLB10}
C {sram512_bitcell.sym} 3520 2520 0 0 {name=xr9c11}
N 3420 2520 3390 2520 {lab=WL9}
N 3390 2520 3390 2620 {lab=WL9}
N 3480 2420 3410 2420 {lab=BL11}
N 3560 2420 3630 2420 {lab=BLB11}
C {sram512_bitcell.sym} 3840 2520 0 0 {name=xr9c12}
N 3740 2520 3710 2520 {lab=WL9}
N 3710 2520 3710 2620 {lab=WL9}
N 3800 2420 3730 2420 {lab=BL12}
N 3880 2420 3950 2420 {lab=BLB12}
C {sram512_bitcell.sym} 4160 2520 0 0 {name=xr9c13}
N 4060 2520 4030 2520 {lab=WL9}
N 4030 2520 4030 2620 {lab=WL9}
N 4120 2420 4050 2420 {lab=BL13}
N 4200 2420 4270 2420 {lab=BLB13}
C {sram512_bitcell.sym} 4480 2520 0 0 {name=xr9c14}
N 4380 2520 4350 2520 {lab=WL9}
N 4350 2520 4350 2620 {lab=WL9}
N 4440 2420 4370 2420 {lab=BL14}
N 4520 2420 4590 2420 {lab=BLB14}
C {sram512_bitcell.sym} 4800 2520 0 0 {name=xr9c15}
N 4700 2520 4670 2520 {lab=WL9}
N 4670 2520 4670 2620 {lab=WL9}
N 4760 2420 4690 2420 {lab=BL15}
N 4840 2420 4910 2420 {lab=BLB15}
C {sram512_bitcell.sym} 5120 2520 0 0 {name=xr9c16}
N 5020 2520 4990 2520 {lab=WL9}
N 4990 2520 4990 2620 {lab=WL9}
N 5080 2420 5010 2420 {lab=BL16}
N 5160 2420 5230 2420 {lab=BLB16}
C {sram512_bitcell.sym} 5440 2520 0 0 {name=xr9c17}
N 5340 2520 5310 2520 {lab=WL9}
N 5310 2520 5310 2620 {lab=WL9}
N 5400 2420 5330 2420 {lab=BL17}
N 5480 2420 5550 2420 {lab=BLB17}
C {sram512_bitcell.sym} 5760 2520 0 0 {name=xr9c18}
N 5660 2520 5630 2520 {lab=WL9}
N 5630 2520 5630 2620 {lab=WL9}
N 5720 2420 5650 2420 {lab=BL18}
N 5800 2420 5870 2420 {lab=BLB18}
C {sram512_bitcell.sym} 6080 2520 0 0 {name=xr9c19}
N 5980 2520 5950 2520 {lab=WL9}
N 5950 2520 5950 2620 {lab=WL9}
N 6040 2420 5970 2420 {lab=BL19}
N 6120 2420 6190 2420 {lab=BLB19}
C {sram512_bitcell.sym} 6400 2520 0 0 {name=xr9c20}
N 6300 2520 6270 2520 {lab=WL9}
N 6270 2520 6270 2620 {lab=WL9}
N 6360 2420 6290 2420 {lab=BL20}
N 6440 2420 6510 2420 {lab=BLB20}
C {sram512_bitcell.sym} 6720 2520 0 0 {name=xr9c21}
N 6620 2520 6590 2520 {lab=WL9}
N 6590 2520 6590 2620 {lab=WL9}
N 6680 2420 6610 2420 {lab=BL21}
N 6760 2420 6830 2420 {lab=BLB21}
C {sram512_bitcell.sym} 7040 2520 0 0 {name=xr9c22}
N 6940 2520 6910 2520 {lab=WL9}
N 6910 2520 6910 2620 {lab=WL9}
N 7000 2420 6930 2420 {lab=BL22}
N 7080 2420 7150 2420 {lab=BLB22}
C {sram512_bitcell.sym} 7360 2520 0 0 {name=xr9c23}
N 7260 2520 7230 2520 {lab=WL9}
N 7230 2520 7230 2620 {lab=WL9}
N 7320 2420 7250 2420 {lab=BL23}
N 7400 2420 7470 2420 {lab=BLB23}
C {sram512_bitcell.sym} 7680 2520 0 0 {name=xr9c24}
N 7580 2520 7550 2520 {lab=WL9}
N 7550 2520 7550 2620 {lab=WL9}
N 7640 2420 7570 2420 {lab=BL24}
N 7720 2420 7790 2420 {lab=BLB24}
C {sram512_bitcell.sym} 8000 2520 0 0 {name=xr9c25}
N 7900 2520 7870 2520 {lab=WL9}
N 7870 2520 7870 2620 {lab=WL9}
N 7960 2420 7890 2420 {lab=BL25}
N 8040 2420 8110 2420 {lab=BLB25}
C {sram512_bitcell.sym} 8320 2520 0 0 {name=xr9c26}
N 8220 2520 8190 2520 {lab=WL9}
N 8190 2520 8190 2620 {lab=WL9}
N 8280 2420 8210 2420 {lab=BL26}
N 8360 2420 8430 2420 {lab=BLB26}
C {sram512_bitcell.sym} 8640 2520 0 0 {name=xr9c27}
N 8540 2520 8510 2520 {lab=WL9}
N 8510 2520 8510 2620 {lab=WL9}
N 8600 2420 8530 2420 {lab=BL27}
N 8680 2420 8750 2420 {lab=BLB27}
C {sram512_bitcell.sym} 8960 2520 0 0 {name=xr9c28}
N 8860 2520 8830 2520 {lab=WL9}
N 8830 2520 8830 2620 {lab=WL9}
N 8920 2420 8850 2420 {lab=BL28}
N 9000 2420 9070 2420 {lab=BLB28}
C {sram512_bitcell.sym} 9280 2520 0 0 {name=xr9c29}
N 9180 2520 9150 2520 {lab=WL9}
N 9150 2520 9150 2620 {lab=WL9}
N 9240 2420 9170 2420 {lab=BL29}
N 9320 2420 9390 2420 {lab=BLB29}
C {sram512_bitcell.sym} 9600 2520 0 0 {name=xr9c30}
N 9500 2520 9470 2520 {lab=WL9}
N 9470 2520 9470 2620 {lab=WL9}
N 9560 2420 9490 2420 {lab=BL30}
N 9640 2420 9710 2420 {lab=BLB30}
C {sram512_bitcell.sym} 9920 2520 0 0 {name=xr9c31}
N 9820 2520 9790 2520 {lab=WL9}
N 9790 2520 9790 2620 {lab=WL9}
N 9880 2420 9810 2420 {lab=BL31}
N 9960 2420 10030 2420 {lab=BLB31}
N -300 2620 9790 2620 {lab=WL9}
C {devices/ipin.sym} -300 2620 0 0 {name=pWL9 lab=WL9}
C {sram512_bitcell.sym} 0 2800 0 0 {name=xr10c0}
N -100 2800 -130 2800 {lab=WL10}
N -130 2800 -130 2900 {lab=WL10}
N -40 2700 -110 2700 {lab=BL0}
N 40 2700 110 2700 {lab=BLB0}
C {sram512_bitcell.sym} 320 2800 0 0 {name=xr10c1}
N 220 2800 190 2800 {lab=WL10}
N 190 2800 190 2900 {lab=WL10}
N 280 2700 210 2700 {lab=BL1}
N 360 2700 430 2700 {lab=BLB1}
C {sram512_bitcell.sym} 640 2800 0 0 {name=xr10c2}
N 540 2800 510 2800 {lab=WL10}
N 510 2800 510 2900 {lab=WL10}
N 600 2700 530 2700 {lab=BL2}
N 680 2700 750 2700 {lab=BLB2}
C {sram512_bitcell.sym} 960 2800 0 0 {name=xr10c3}
N 860 2800 830 2800 {lab=WL10}
N 830 2800 830 2900 {lab=WL10}
N 920 2700 850 2700 {lab=BL3}
N 1000 2700 1070 2700 {lab=BLB3}
C {sram512_bitcell.sym} 1280 2800 0 0 {name=xr10c4}
N 1180 2800 1150 2800 {lab=WL10}
N 1150 2800 1150 2900 {lab=WL10}
N 1240 2700 1170 2700 {lab=BL4}
N 1320 2700 1390 2700 {lab=BLB4}
C {sram512_bitcell.sym} 1600 2800 0 0 {name=xr10c5}
N 1500 2800 1470 2800 {lab=WL10}
N 1470 2800 1470 2900 {lab=WL10}
N 1560 2700 1490 2700 {lab=BL5}
N 1640 2700 1710 2700 {lab=BLB5}
C {sram512_bitcell.sym} 1920 2800 0 0 {name=xr10c6}
N 1820 2800 1790 2800 {lab=WL10}
N 1790 2800 1790 2900 {lab=WL10}
N 1880 2700 1810 2700 {lab=BL6}
N 1960 2700 2030 2700 {lab=BLB6}
C {sram512_bitcell.sym} 2240 2800 0 0 {name=xr10c7}
N 2140 2800 2110 2800 {lab=WL10}
N 2110 2800 2110 2900 {lab=WL10}
N 2200 2700 2130 2700 {lab=BL7}
N 2280 2700 2350 2700 {lab=BLB7}
C {sram512_bitcell.sym} 2560 2800 0 0 {name=xr10c8}
N 2460 2800 2430 2800 {lab=WL10}
N 2430 2800 2430 2900 {lab=WL10}
N 2520 2700 2450 2700 {lab=BL8}
N 2600 2700 2670 2700 {lab=BLB8}
C {sram512_bitcell.sym} 2880 2800 0 0 {name=xr10c9}
N 2780 2800 2750 2800 {lab=WL10}
N 2750 2800 2750 2900 {lab=WL10}
N 2840 2700 2770 2700 {lab=BL9}
N 2920 2700 2990 2700 {lab=BLB9}
C {sram512_bitcell.sym} 3200 2800 0 0 {name=xr10c10}
N 3100 2800 3070 2800 {lab=WL10}
N 3070 2800 3070 2900 {lab=WL10}
N 3160 2700 3090 2700 {lab=BL10}
N 3240 2700 3310 2700 {lab=BLB10}
C {sram512_bitcell.sym} 3520 2800 0 0 {name=xr10c11}
N 3420 2800 3390 2800 {lab=WL10}
N 3390 2800 3390 2900 {lab=WL10}
N 3480 2700 3410 2700 {lab=BL11}
N 3560 2700 3630 2700 {lab=BLB11}
C {sram512_bitcell.sym} 3840 2800 0 0 {name=xr10c12}
N 3740 2800 3710 2800 {lab=WL10}
N 3710 2800 3710 2900 {lab=WL10}
N 3800 2700 3730 2700 {lab=BL12}
N 3880 2700 3950 2700 {lab=BLB12}
C {sram512_bitcell.sym} 4160 2800 0 0 {name=xr10c13}
N 4060 2800 4030 2800 {lab=WL10}
N 4030 2800 4030 2900 {lab=WL10}
N 4120 2700 4050 2700 {lab=BL13}
N 4200 2700 4270 2700 {lab=BLB13}
C {sram512_bitcell.sym} 4480 2800 0 0 {name=xr10c14}
N 4380 2800 4350 2800 {lab=WL10}
N 4350 2800 4350 2900 {lab=WL10}
N 4440 2700 4370 2700 {lab=BL14}
N 4520 2700 4590 2700 {lab=BLB14}
C {sram512_bitcell.sym} 4800 2800 0 0 {name=xr10c15}
N 4700 2800 4670 2800 {lab=WL10}
N 4670 2800 4670 2900 {lab=WL10}
N 4760 2700 4690 2700 {lab=BL15}
N 4840 2700 4910 2700 {lab=BLB15}
C {sram512_bitcell.sym} 5120 2800 0 0 {name=xr10c16}
N 5020 2800 4990 2800 {lab=WL10}
N 4990 2800 4990 2900 {lab=WL10}
N 5080 2700 5010 2700 {lab=BL16}
N 5160 2700 5230 2700 {lab=BLB16}
C {sram512_bitcell.sym} 5440 2800 0 0 {name=xr10c17}
N 5340 2800 5310 2800 {lab=WL10}
N 5310 2800 5310 2900 {lab=WL10}
N 5400 2700 5330 2700 {lab=BL17}
N 5480 2700 5550 2700 {lab=BLB17}
C {sram512_bitcell.sym} 5760 2800 0 0 {name=xr10c18}
N 5660 2800 5630 2800 {lab=WL10}
N 5630 2800 5630 2900 {lab=WL10}
N 5720 2700 5650 2700 {lab=BL18}
N 5800 2700 5870 2700 {lab=BLB18}
C {sram512_bitcell.sym} 6080 2800 0 0 {name=xr10c19}
N 5980 2800 5950 2800 {lab=WL10}
N 5950 2800 5950 2900 {lab=WL10}
N 6040 2700 5970 2700 {lab=BL19}
N 6120 2700 6190 2700 {lab=BLB19}
C {sram512_bitcell.sym} 6400 2800 0 0 {name=xr10c20}
N 6300 2800 6270 2800 {lab=WL10}
N 6270 2800 6270 2900 {lab=WL10}
N 6360 2700 6290 2700 {lab=BL20}
N 6440 2700 6510 2700 {lab=BLB20}
C {sram512_bitcell.sym} 6720 2800 0 0 {name=xr10c21}
N 6620 2800 6590 2800 {lab=WL10}
N 6590 2800 6590 2900 {lab=WL10}
N 6680 2700 6610 2700 {lab=BL21}
N 6760 2700 6830 2700 {lab=BLB21}
C {sram512_bitcell.sym} 7040 2800 0 0 {name=xr10c22}
N 6940 2800 6910 2800 {lab=WL10}
N 6910 2800 6910 2900 {lab=WL10}
N 7000 2700 6930 2700 {lab=BL22}
N 7080 2700 7150 2700 {lab=BLB22}
C {sram512_bitcell.sym} 7360 2800 0 0 {name=xr10c23}
N 7260 2800 7230 2800 {lab=WL10}
N 7230 2800 7230 2900 {lab=WL10}
N 7320 2700 7250 2700 {lab=BL23}
N 7400 2700 7470 2700 {lab=BLB23}
C {sram512_bitcell.sym} 7680 2800 0 0 {name=xr10c24}
N 7580 2800 7550 2800 {lab=WL10}
N 7550 2800 7550 2900 {lab=WL10}
N 7640 2700 7570 2700 {lab=BL24}
N 7720 2700 7790 2700 {lab=BLB24}
C {sram512_bitcell.sym} 8000 2800 0 0 {name=xr10c25}
N 7900 2800 7870 2800 {lab=WL10}
N 7870 2800 7870 2900 {lab=WL10}
N 7960 2700 7890 2700 {lab=BL25}
N 8040 2700 8110 2700 {lab=BLB25}
C {sram512_bitcell.sym} 8320 2800 0 0 {name=xr10c26}
N 8220 2800 8190 2800 {lab=WL10}
N 8190 2800 8190 2900 {lab=WL10}
N 8280 2700 8210 2700 {lab=BL26}
N 8360 2700 8430 2700 {lab=BLB26}
C {sram512_bitcell.sym} 8640 2800 0 0 {name=xr10c27}
N 8540 2800 8510 2800 {lab=WL10}
N 8510 2800 8510 2900 {lab=WL10}
N 8600 2700 8530 2700 {lab=BL27}
N 8680 2700 8750 2700 {lab=BLB27}
C {sram512_bitcell.sym} 8960 2800 0 0 {name=xr10c28}
N 8860 2800 8830 2800 {lab=WL10}
N 8830 2800 8830 2900 {lab=WL10}
N 8920 2700 8850 2700 {lab=BL28}
N 9000 2700 9070 2700 {lab=BLB28}
C {sram512_bitcell.sym} 9280 2800 0 0 {name=xr10c29}
N 9180 2800 9150 2800 {lab=WL10}
N 9150 2800 9150 2900 {lab=WL10}
N 9240 2700 9170 2700 {lab=BL29}
N 9320 2700 9390 2700 {lab=BLB29}
C {sram512_bitcell.sym} 9600 2800 0 0 {name=xr10c30}
N 9500 2800 9470 2800 {lab=WL10}
N 9470 2800 9470 2900 {lab=WL10}
N 9560 2700 9490 2700 {lab=BL30}
N 9640 2700 9710 2700 {lab=BLB30}
C {sram512_bitcell.sym} 9920 2800 0 0 {name=xr10c31}
N 9820 2800 9790 2800 {lab=WL10}
N 9790 2800 9790 2900 {lab=WL10}
N 9880 2700 9810 2700 {lab=BL31}
N 9960 2700 10030 2700 {lab=BLB31}
N -300 2900 9790 2900 {lab=WL10}
C {devices/ipin.sym} -300 2900 0 0 {name=pWL10 lab=WL10}
C {sram512_bitcell.sym} 0 3080 0 0 {name=xr11c0}
N -100 3080 -130 3080 {lab=WL11}
N -130 3080 -130 3180 {lab=WL11}
N -40 2980 -110 2980 {lab=BL0}
N 40 2980 110 2980 {lab=BLB0}
C {sram512_bitcell.sym} 320 3080 0 0 {name=xr11c1}
N 220 3080 190 3080 {lab=WL11}
N 190 3080 190 3180 {lab=WL11}
N 280 2980 210 2980 {lab=BL1}
N 360 2980 430 2980 {lab=BLB1}
C {sram512_bitcell.sym} 640 3080 0 0 {name=xr11c2}
N 540 3080 510 3080 {lab=WL11}
N 510 3080 510 3180 {lab=WL11}
N 600 2980 530 2980 {lab=BL2}
N 680 2980 750 2980 {lab=BLB2}
C {sram512_bitcell.sym} 960 3080 0 0 {name=xr11c3}
N 860 3080 830 3080 {lab=WL11}
N 830 3080 830 3180 {lab=WL11}
N 920 2980 850 2980 {lab=BL3}
N 1000 2980 1070 2980 {lab=BLB3}
C {sram512_bitcell.sym} 1280 3080 0 0 {name=xr11c4}
N 1180 3080 1150 3080 {lab=WL11}
N 1150 3080 1150 3180 {lab=WL11}
N 1240 2980 1170 2980 {lab=BL4}
N 1320 2980 1390 2980 {lab=BLB4}
C {sram512_bitcell.sym} 1600 3080 0 0 {name=xr11c5}
N 1500 3080 1470 3080 {lab=WL11}
N 1470 3080 1470 3180 {lab=WL11}
N 1560 2980 1490 2980 {lab=BL5}
N 1640 2980 1710 2980 {lab=BLB5}
C {sram512_bitcell.sym} 1920 3080 0 0 {name=xr11c6}
N 1820 3080 1790 3080 {lab=WL11}
N 1790 3080 1790 3180 {lab=WL11}
N 1880 2980 1810 2980 {lab=BL6}
N 1960 2980 2030 2980 {lab=BLB6}
C {sram512_bitcell.sym} 2240 3080 0 0 {name=xr11c7}
N 2140 3080 2110 3080 {lab=WL11}
N 2110 3080 2110 3180 {lab=WL11}
N 2200 2980 2130 2980 {lab=BL7}
N 2280 2980 2350 2980 {lab=BLB7}
C {sram512_bitcell.sym} 2560 3080 0 0 {name=xr11c8}
N 2460 3080 2430 3080 {lab=WL11}
N 2430 3080 2430 3180 {lab=WL11}
N 2520 2980 2450 2980 {lab=BL8}
N 2600 2980 2670 2980 {lab=BLB8}
C {sram512_bitcell.sym} 2880 3080 0 0 {name=xr11c9}
N 2780 3080 2750 3080 {lab=WL11}
N 2750 3080 2750 3180 {lab=WL11}
N 2840 2980 2770 2980 {lab=BL9}
N 2920 2980 2990 2980 {lab=BLB9}
C {sram512_bitcell.sym} 3200 3080 0 0 {name=xr11c10}
N 3100 3080 3070 3080 {lab=WL11}
N 3070 3080 3070 3180 {lab=WL11}
N 3160 2980 3090 2980 {lab=BL10}
N 3240 2980 3310 2980 {lab=BLB10}
C {sram512_bitcell.sym} 3520 3080 0 0 {name=xr11c11}
N 3420 3080 3390 3080 {lab=WL11}
N 3390 3080 3390 3180 {lab=WL11}
N 3480 2980 3410 2980 {lab=BL11}
N 3560 2980 3630 2980 {lab=BLB11}
C {sram512_bitcell.sym} 3840 3080 0 0 {name=xr11c12}
N 3740 3080 3710 3080 {lab=WL11}
N 3710 3080 3710 3180 {lab=WL11}
N 3800 2980 3730 2980 {lab=BL12}
N 3880 2980 3950 2980 {lab=BLB12}
C {sram512_bitcell.sym} 4160 3080 0 0 {name=xr11c13}
N 4060 3080 4030 3080 {lab=WL11}
N 4030 3080 4030 3180 {lab=WL11}
N 4120 2980 4050 2980 {lab=BL13}
N 4200 2980 4270 2980 {lab=BLB13}
C {sram512_bitcell.sym} 4480 3080 0 0 {name=xr11c14}
N 4380 3080 4350 3080 {lab=WL11}
N 4350 3080 4350 3180 {lab=WL11}
N 4440 2980 4370 2980 {lab=BL14}
N 4520 2980 4590 2980 {lab=BLB14}
C {sram512_bitcell.sym} 4800 3080 0 0 {name=xr11c15}
N 4700 3080 4670 3080 {lab=WL11}
N 4670 3080 4670 3180 {lab=WL11}
N 4760 2980 4690 2980 {lab=BL15}
N 4840 2980 4910 2980 {lab=BLB15}
C {sram512_bitcell.sym} 5120 3080 0 0 {name=xr11c16}
N 5020 3080 4990 3080 {lab=WL11}
N 4990 3080 4990 3180 {lab=WL11}
N 5080 2980 5010 2980 {lab=BL16}
N 5160 2980 5230 2980 {lab=BLB16}
C {sram512_bitcell.sym} 5440 3080 0 0 {name=xr11c17}
N 5340 3080 5310 3080 {lab=WL11}
N 5310 3080 5310 3180 {lab=WL11}
N 5400 2980 5330 2980 {lab=BL17}
N 5480 2980 5550 2980 {lab=BLB17}
C {sram512_bitcell.sym} 5760 3080 0 0 {name=xr11c18}
N 5660 3080 5630 3080 {lab=WL11}
N 5630 3080 5630 3180 {lab=WL11}
N 5720 2980 5650 2980 {lab=BL18}
N 5800 2980 5870 2980 {lab=BLB18}
C {sram512_bitcell.sym} 6080 3080 0 0 {name=xr11c19}
N 5980 3080 5950 3080 {lab=WL11}
N 5950 3080 5950 3180 {lab=WL11}
N 6040 2980 5970 2980 {lab=BL19}
N 6120 2980 6190 2980 {lab=BLB19}
C {sram512_bitcell.sym} 6400 3080 0 0 {name=xr11c20}
N 6300 3080 6270 3080 {lab=WL11}
N 6270 3080 6270 3180 {lab=WL11}
N 6360 2980 6290 2980 {lab=BL20}
N 6440 2980 6510 2980 {lab=BLB20}
C {sram512_bitcell.sym} 6720 3080 0 0 {name=xr11c21}
N 6620 3080 6590 3080 {lab=WL11}
N 6590 3080 6590 3180 {lab=WL11}
N 6680 2980 6610 2980 {lab=BL21}
N 6760 2980 6830 2980 {lab=BLB21}
C {sram512_bitcell.sym} 7040 3080 0 0 {name=xr11c22}
N 6940 3080 6910 3080 {lab=WL11}
N 6910 3080 6910 3180 {lab=WL11}
N 7000 2980 6930 2980 {lab=BL22}
N 7080 2980 7150 2980 {lab=BLB22}
C {sram512_bitcell.sym} 7360 3080 0 0 {name=xr11c23}
N 7260 3080 7230 3080 {lab=WL11}
N 7230 3080 7230 3180 {lab=WL11}
N 7320 2980 7250 2980 {lab=BL23}
N 7400 2980 7470 2980 {lab=BLB23}
C {sram512_bitcell.sym} 7680 3080 0 0 {name=xr11c24}
N 7580 3080 7550 3080 {lab=WL11}
N 7550 3080 7550 3180 {lab=WL11}
N 7640 2980 7570 2980 {lab=BL24}
N 7720 2980 7790 2980 {lab=BLB24}
C {sram512_bitcell.sym} 8000 3080 0 0 {name=xr11c25}
N 7900 3080 7870 3080 {lab=WL11}
N 7870 3080 7870 3180 {lab=WL11}
N 7960 2980 7890 2980 {lab=BL25}
N 8040 2980 8110 2980 {lab=BLB25}
C {sram512_bitcell.sym} 8320 3080 0 0 {name=xr11c26}
N 8220 3080 8190 3080 {lab=WL11}
N 8190 3080 8190 3180 {lab=WL11}
N 8280 2980 8210 2980 {lab=BL26}
N 8360 2980 8430 2980 {lab=BLB26}
C {sram512_bitcell.sym} 8640 3080 0 0 {name=xr11c27}
N 8540 3080 8510 3080 {lab=WL11}
N 8510 3080 8510 3180 {lab=WL11}
N 8600 2980 8530 2980 {lab=BL27}
N 8680 2980 8750 2980 {lab=BLB27}
C {sram512_bitcell.sym} 8960 3080 0 0 {name=xr11c28}
N 8860 3080 8830 3080 {lab=WL11}
N 8830 3080 8830 3180 {lab=WL11}
N 8920 2980 8850 2980 {lab=BL28}
N 9000 2980 9070 2980 {lab=BLB28}
C {sram512_bitcell.sym} 9280 3080 0 0 {name=xr11c29}
N 9180 3080 9150 3080 {lab=WL11}
N 9150 3080 9150 3180 {lab=WL11}
N 9240 2980 9170 2980 {lab=BL29}
N 9320 2980 9390 2980 {lab=BLB29}
C {sram512_bitcell.sym} 9600 3080 0 0 {name=xr11c30}
N 9500 3080 9470 3080 {lab=WL11}
N 9470 3080 9470 3180 {lab=WL11}
N 9560 2980 9490 2980 {lab=BL30}
N 9640 2980 9710 2980 {lab=BLB30}
C {sram512_bitcell.sym} 9920 3080 0 0 {name=xr11c31}
N 9820 3080 9790 3080 {lab=WL11}
N 9790 3080 9790 3180 {lab=WL11}
N 9880 2980 9810 2980 {lab=BL31}
N 9960 2980 10030 2980 {lab=BLB31}
N -300 3180 9790 3180 {lab=WL11}
C {devices/ipin.sym} -300 3180 0 0 {name=pWL11 lab=WL11}
C {sram512_bitcell.sym} 0 3360 0 0 {name=xr12c0}
N -100 3360 -130 3360 {lab=WL12}
N -130 3360 -130 3460 {lab=WL12}
N -40 3260 -110 3260 {lab=BL0}
N 40 3260 110 3260 {lab=BLB0}
C {sram512_bitcell.sym} 320 3360 0 0 {name=xr12c1}
N 220 3360 190 3360 {lab=WL12}
N 190 3360 190 3460 {lab=WL12}
N 280 3260 210 3260 {lab=BL1}
N 360 3260 430 3260 {lab=BLB1}
C {sram512_bitcell.sym} 640 3360 0 0 {name=xr12c2}
N 540 3360 510 3360 {lab=WL12}
N 510 3360 510 3460 {lab=WL12}
N 600 3260 530 3260 {lab=BL2}
N 680 3260 750 3260 {lab=BLB2}
C {sram512_bitcell.sym} 960 3360 0 0 {name=xr12c3}
N 860 3360 830 3360 {lab=WL12}
N 830 3360 830 3460 {lab=WL12}
N 920 3260 850 3260 {lab=BL3}
N 1000 3260 1070 3260 {lab=BLB3}
C {sram512_bitcell.sym} 1280 3360 0 0 {name=xr12c4}
N 1180 3360 1150 3360 {lab=WL12}
N 1150 3360 1150 3460 {lab=WL12}
N 1240 3260 1170 3260 {lab=BL4}
N 1320 3260 1390 3260 {lab=BLB4}
C {sram512_bitcell.sym} 1600 3360 0 0 {name=xr12c5}
N 1500 3360 1470 3360 {lab=WL12}
N 1470 3360 1470 3460 {lab=WL12}
N 1560 3260 1490 3260 {lab=BL5}
N 1640 3260 1710 3260 {lab=BLB5}
C {sram512_bitcell.sym} 1920 3360 0 0 {name=xr12c6}
N 1820 3360 1790 3360 {lab=WL12}
N 1790 3360 1790 3460 {lab=WL12}
N 1880 3260 1810 3260 {lab=BL6}
N 1960 3260 2030 3260 {lab=BLB6}
C {sram512_bitcell.sym} 2240 3360 0 0 {name=xr12c7}
N 2140 3360 2110 3360 {lab=WL12}
N 2110 3360 2110 3460 {lab=WL12}
N 2200 3260 2130 3260 {lab=BL7}
N 2280 3260 2350 3260 {lab=BLB7}
C {sram512_bitcell.sym} 2560 3360 0 0 {name=xr12c8}
N 2460 3360 2430 3360 {lab=WL12}
N 2430 3360 2430 3460 {lab=WL12}
N 2520 3260 2450 3260 {lab=BL8}
N 2600 3260 2670 3260 {lab=BLB8}
C {sram512_bitcell.sym} 2880 3360 0 0 {name=xr12c9}
N 2780 3360 2750 3360 {lab=WL12}
N 2750 3360 2750 3460 {lab=WL12}
N 2840 3260 2770 3260 {lab=BL9}
N 2920 3260 2990 3260 {lab=BLB9}
C {sram512_bitcell.sym} 3200 3360 0 0 {name=xr12c10}
N 3100 3360 3070 3360 {lab=WL12}
N 3070 3360 3070 3460 {lab=WL12}
N 3160 3260 3090 3260 {lab=BL10}
N 3240 3260 3310 3260 {lab=BLB10}
C {sram512_bitcell.sym} 3520 3360 0 0 {name=xr12c11}
N 3420 3360 3390 3360 {lab=WL12}
N 3390 3360 3390 3460 {lab=WL12}
N 3480 3260 3410 3260 {lab=BL11}
N 3560 3260 3630 3260 {lab=BLB11}
C {sram512_bitcell.sym} 3840 3360 0 0 {name=xr12c12}
N 3740 3360 3710 3360 {lab=WL12}
N 3710 3360 3710 3460 {lab=WL12}
N 3800 3260 3730 3260 {lab=BL12}
N 3880 3260 3950 3260 {lab=BLB12}
C {sram512_bitcell.sym} 4160 3360 0 0 {name=xr12c13}
N 4060 3360 4030 3360 {lab=WL12}
N 4030 3360 4030 3460 {lab=WL12}
N 4120 3260 4050 3260 {lab=BL13}
N 4200 3260 4270 3260 {lab=BLB13}
C {sram512_bitcell.sym} 4480 3360 0 0 {name=xr12c14}
N 4380 3360 4350 3360 {lab=WL12}
N 4350 3360 4350 3460 {lab=WL12}
N 4440 3260 4370 3260 {lab=BL14}
N 4520 3260 4590 3260 {lab=BLB14}
C {sram512_bitcell.sym} 4800 3360 0 0 {name=xr12c15}
N 4700 3360 4670 3360 {lab=WL12}
N 4670 3360 4670 3460 {lab=WL12}
N 4760 3260 4690 3260 {lab=BL15}
N 4840 3260 4910 3260 {lab=BLB15}
C {sram512_bitcell.sym} 5120 3360 0 0 {name=xr12c16}
N 5020 3360 4990 3360 {lab=WL12}
N 4990 3360 4990 3460 {lab=WL12}
N 5080 3260 5010 3260 {lab=BL16}
N 5160 3260 5230 3260 {lab=BLB16}
C {sram512_bitcell.sym} 5440 3360 0 0 {name=xr12c17}
N 5340 3360 5310 3360 {lab=WL12}
N 5310 3360 5310 3460 {lab=WL12}
N 5400 3260 5330 3260 {lab=BL17}
N 5480 3260 5550 3260 {lab=BLB17}
C {sram512_bitcell.sym} 5760 3360 0 0 {name=xr12c18}
N 5660 3360 5630 3360 {lab=WL12}
N 5630 3360 5630 3460 {lab=WL12}
N 5720 3260 5650 3260 {lab=BL18}
N 5800 3260 5870 3260 {lab=BLB18}
C {sram512_bitcell.sym} 6080 3360 0 0 {name=xr12c19}
N 5980 3360 5950 3360 {lab=WL12}
N 5950 3360 5950 3460 {lab=WL12}
N 6040 3260 5970 3260 {lab=BL19}
N 6120 3260 6190 3260 {lab=BLB19}
C {sram512_bitcell.sym} 6400 3360 0 0 {name=xr12c20}
N 6300 3360 6270 3360 {lab=WL12}
N 6270 3360 6270 3460 {lab=WL12}
N 6360 3260 6290 3260 {lab=BL20}
N 6440 3260 6510 3260 {lab=BLB20}
C {sram512_bitcell.sym} 6720 3360 0 0 {name=xr12c21}
N 6620 3360 6590 3360 {lab=WL12}
N 6590 3360 6590 3460 {lab=WL12}
N 6680 3260 6610 3260 {lab=BL21}
N 6760 3260 6830 3260 {lab=BLB21}
C {sram512_bitcell.sym} 7040 3360 0 0 {name=xr12c22}
N 6940 3360 6910 3360 {lab=WL12}
N 6910 3360 6910 3460 {lab=WL12}
N 7000 3260 6930 3260 {lab=BL22}
N 7080 3260 7150 3260 {lab=BLB22}
C {sram512_bitcell.sym} 7360 3360 0 0 {name=xr12c23}
N 7260 3360 7230 3360 {lab=WL12}
N 7230 3360 7230 3460 {lab=WL12}
N 7320 3260 7250 3260 {lab=BL23}
N 7400 3260 7470 3260 {lab=BLB23}
C {sram512_bitcell.sym} 7680 3360 0 0 {name=xr12c24}
N 7580 3360 7550 3360 {lab=WL12}
N 7550 3360 7550 3460 {lab=WL12}
N 7640 3260 7570 3260 {lab=BL24}
N 7720 3260 7790 3260 {lab=BLB24}
C {sram512_bitcell.sym} 8000 3360 0 0 {name=xr12c25}
N 7900 3360 7870 3360 {lab=WL12}
N 7870 3360 7870 3460 {lab=WL12}
N 7960 3260 7890 3260 {lab=BL25}
N 8040 3260 8110 3260 {lab=BLB25}
C {sram512_bitcell.sym} 8320 3360 0 0 {name=xr12c26}
N 8220 3360 8190 3360 {lab=WL12}
N 8190 3360 8190 3460 {lab=WL12}
N 8280 3260 8210 3260 {lab=BL26}
N 8360 3260 8430 3260 {lab=BLB26}
C {sram512_bitcell.sym} 8640 3360 0 0 {name=xr12c27}
N 8540 3360 8510 3360 {lab=WL12}
N 8510 3360 8510 3460 {lab=WL12}
N 8600 3260 8530 3260 {lab=BL27}
N 8680 3260 8750 3260 {lab=BLB27}
C {sram512_bitcell.sym} 8960 3360 0 0 {name=xr12c28}
N 8860 3360 8830 3360 {lab=WL12}
N 8830 3360 8830 3460 {lab=WL12}
N 8920 3260 8850 3260 {lab=BL28}
N 9000 3260 9070 3260 {lab=BLB28}
C {sram512_bitcell.sym} 9280 3360 0 0 {name=xr12c29}
N 9180 3360 9150 3360 {lab=WL12}
N 9150 3360 9150 3460 {lab=WL12}
N 9240 3260 9170 3260 {lab=BL29}
N 9320 3260 9390 3260 {lab=BLB29}
C {sram512_bitcell.sym} 9600 3360 0 0 {name=xr12c30}
N 9500 3360 9470 3360 {lab=WL12}
N 9470 3360 9470 3460 {lab=WL12}
N 9560 3260 9490 3260 {lab=BL30}
N 9640 3260 9710 3260 {lab=BLB30}
C {sram512_bitcell.sym} 9920 3360 0 0 {name=xr12c31}
N 9820 3360 9790 3360 {lab=WL12}
N 9790 3360 9790 3460 {lab=WL12}
N 9880 3260 9810 3260 {lab=BL31}
N 9960 3260 10030 3260 {lab=BLB31}
N -300 3460 9790 3460 {lab=WL12}
C {devices/ipin.sym} -300 3460 0 0 {name=pWL12 lab=WL12}
C {sram512_bitcell.sym} 0 3640 0 0 {name=xr13c0}
N -100 3640 -130 3640 {lab=WL13}
N -130 3640 -130 3740 {lab=WL13}
N -40 3540 -110 3540 {lab=BL0}
N 40 3540 110 3540 {lab=BLB0}
C {sram512_bitcell.sym} 320 3640 0 0 {name=xr13c1}
N 220 3640 190 3640 {lab=WL13}
N 190 3640 190 3740 {lab=WL13}
N 280 3540 210 3540 {lab=BL1}
N 360 3540 430 3540 {lab=BLB1}
C {sram512_bitcell.sym} 640 3640 0 0 {name=xr13c2}
N 540 3640 510 3640 {lab=WL13}
N 510 3640 510 3740 {lab=WL13}
N 600 3540 530 3540 {lab=BL2}
N 680 3540 750 3540 {lab=BLB2}
C {sram512_bitcell.sym} 960 3640 0 0 {name=xr13c3}
N 860 3640 830 3640 {lab=WL13}
N 830 3640 830 3740 {lab=WL13}
N 920 3540 850 3540 {lab=BL3}
N 1000 3540 1070 3540 {lab=BLB3}
C {sram512_bitcell.sym} 1280 3640 0 0 {name=xr13c4}
N 1180 3640 1150 3640 {lab=WL13}
N 1150 3640 1150 3740 {lab=WL13}
N 1240 3540 1170 3540 {lab=BL4}
N 1320 3540 1390 3540 {lab=BLB4}
C {sram512_bitcell.sym} 1600 3640 0 0 {name=xr13c5}
N 1500 3640 1470 3640 {lab=WL13}
N 1470 3640 1470 3740 {lab=WL13}
N 1560 3540 1490 3540 {lab=BL5}
N 1640 3540 1710 3540 {lab=BLB5}
C {sram512_bitcell.sym} 1920 3640 0 0 {name=xr13c6}
N 1820 3640 1790 3640 {lab=WL13}
N 1790 3640 1790 3740 {lab=WL13}
N 1880 3540 1810 3540 {lab=BL6}
N 1960 3540 2030 3540 {lab=BLB6}
C {sram512_bitcell.sym} 2240 3640 0 0 {name=xr13c7}
N 2140 3640 2110 3640 {lab=WL13}
N 2110 3640 2110 3740 {lab=WL13}
N 2200 3540 2130 3540 {lab=BL7}
N 2280 3540 2350 3540 {lab=BLB7}
C {sram512_bitcell.sym} 2560 3640 0 0 {name=xr13c8}
N 2460 3640 2430 3640 {lab=WL13}
N 2430 3640 2430 3740 {lab=WL13}
N 2520 3540 2450 3540 {lab=BL8}
N 2600 3540 2670 3540 {lab=BLB8}
C {sram512_bitcell.sym} 2880 3640 0 0 {name=xr13c9}
N 2780 3640 2750 3640 {lab=WL13}
N 2750 3640 2750 3740 {lab=WL13}
N 2840 3540 2770 3540 {lab=BL9}
N 2920 3540 2990 3540 {lab=BLB9}
C {sram512_bitcell.sym} 3200 3640 0 0 {name=xr13c10}
N 3100 3640 3070 3640 {lab=WL13}
N 3070 3640 3070 3740 {lab=WL13}
N 3160 3540 3090 3540 {lab=BL10}
N 3240 3540 3310 3540 {lab=BLB10}
C {sram512_bitcell.sym} 3520 3640 0 0 {name=xr13c11}
N 3420 3640 3390 3640 {lab=WL13}
N 3390 3640 3390 3740 {lab=WL13}
N 3480 3540 3410 3540 {lab=BL11}
N 3560 3540 3630 3540 {lab=BLB11}
C {sram512_bitcell.sym} 3840 3640 0 0 {name=xr13c12}
N 3740 3640 3710 3640 {lab=WL13}
N 3710 3640 3710 3740 {lab=WL13}
N 3800 3540 3730 3540 {lab=BL12}
N 3880 3540 3950 3540 {lab=BLB12}
C {sram512_bitcell.sym} 4160 3640 0 0 {name=xr13c13}
N 4060 3640 4030 3640 {lab=WL13}
N 4030 3640 4030 3740 {lab=WL13}
N 4120 3540 4050 3540 {lab=BL13}
N 4200 3540 4270 3540 {lab=BLB13}
C {sram512_bitcell.sym} 4480 3640 0 0 {name=xr13c14}
N 4380 3640 4350 3640 {lab=WL13}
N 4350 3640 4350 3740 {lab=WL13}
N 4440 3540 4370 3540 {lab=BL14}
N 4520 3540 4590 3540 {lab=BLB14}
C {sram512_bitcell.sym} 4800 3640 0 0 {name=xr13c15}
N 4700 3640 4670 3640 {lab=WL13}
N 4670 3640 4670 3740 {lab=WL13}
N 4760 3540 4690 3540 {lab=BL15}
N 4840 3540 4910 3540 {lab=BLB15}
C {sram512_bitcell.sym} 5120 3640 0 0 {name=xr13c16}
N 5020 3640 4990 3640 {lab=WL13}
N 4990 3640 4990 3740 {lab=WL13}
N 5080 3540 5010 3540 {lab=BL16}
N 5160 3540 5230 3540 {lab=BLB16}
C {sram512_bitcell.sym} 5440 3640 0 0 {name=xr13c17}
N 5340 3640 5310 3640 {lab=WL13}
N 5310 3640 5310 3740 {lab=WL13}
N 5400 3540 5330 3540 {lab=BL17}
N 5480 3540 5550 3540 {lab=BLB17}
C {sram512_bitcell.sym} 5760 3640 0 0 {name=xr13c18}
N 5660 3640 5630 3640 {lab=WL13}
N 5630 3640 5630 3740 {lab=WL13}
N 5720 3540 5650 3540 {lab=BL18}
N 5800 3540 5870 3540 {lab=BLB18}
C {sram512_bitcell.sym} 6080 3640 0 0 {name=xr13c19}
N 5980 3640 5950 3640 {lab=WL13}
N 5950 3640 5950 3740 {lab=WL13}
N 6040 3540 5970 3540 {lab=BL19}
N 6120 3540 6190 3540 {lab=BLB19}
C {sram512_bitcell.sym} 6400 3640 0 0 {name=xr13c20}
N 6300 3640 6270 3640 {lab=WL13}
N 6270 3640 6270 3740 {lab=WL13}
N 6360 3540 6290 3540 {lab=BL20}
N 6440 3540 6510 3540 {lab=BLB20}
C {sram512_bitcell.sym} 6720 3640 0 0 {name=xr13c21}
N 6620 3640 6590 3640 {lab=WL13}
N 6590 3640 6590 3740 {lab=WL13}
N 6680 3540 6610 3540 {lab=BL21}
N 6760 3540 6830 3540 {lab=BLB21}
C {sram512_bitcell.sym} 7040 3640 0 0 {name=xr13c22}
N 6940 3640 6910 3640 {lab=WL13}
N 6910 3640 6910 3740 {lab=WL13}
N 7000 3540 6930 3540 {lab=BL22}
N 7080 3540 7150 3540 {lab=BLB22}
C {sram512_bitcell.sym} 7360 3640 0 0 {name=xr13c23}
N 7260 3640 7230 3640 {lab=WL13}
N 7230 3640 7230 3740 {lab=WL13}
N 7320 3540 7250 3540 {lab=BL23}
N 7400 3540 7470 3540 {lab=BLB23}
C {sram512_bitcell.sym} 7680 3640 0 0 {name=xr13c24}
N 7580 3640 7550 3640 {lab=WL13}
N 7550 3640 7550 3740 {lab=WL13}
N 7640 3540 7570 3540 {lab=BL24}
N 7720 3540 7790 3540 {lab=BLB24}
C {sram512_bitcell.sym} 8000 3640 0 0 {name=xr13c25}
N 7900 3640 7870 3640 {lab=WL13}
N 7870 3640 7870 3740 {lab=WL13}
N 7960 3540 7890 3540 {lab=BL25}
N 8040 3540 8110 3540 {lab=BLB25}
C {sram512_bitcell.sym} 8320 3640 0 0 {name=xr13c26}
N 8220 3640 8190 3640 {lab=WL13}
N 8190 3640 8190 3740 {lab=WL13}
N 8280 3540 8210 3540 {lab=BL26}
N 8360 3540 8430 3540 {lab=BLB26}
C {sram512_bitcell.sym} 8640 3640 0 0 {name=xr13c27}
N 8540 3640 8510 3640 {lab=WL13}
N 8510 3640 8510 3740 {lab=WL13}
N 8600 3540 8530 3540 {lab=BL27}
N 8680 3540 8750 3540 {lab=BLB27}
C {sram512_bitcell.sym} 8960 3640 0 0 {name=xr13c28}
N 8860 3640 8830 3640 {lab=WL13}
N 8830 3640 8830 3740 {lab=WL13}
N 8920 3540 8850 3540 {lab=BL28}
N 9000 3540 9070 3540 {lab=BLB28}
C {sram512_bitcell.sym} 9280 3640 0 0 {name=xr13c29}
N 9180 3640 9150 3640 {lab=WL13}
N 9150 3640 9150 3740 {lab=WL13}
N 9240 3540 9170 3540 {lab=BL29}
N 9320 3540 9390 3540 {lab=BLB29}
C {sram512_bitcell.sym} 9600 3640 0 0 {name=xr13c30}
N 9500 3640 9470 3640 {lab=WL13}
N 9470 3640 9470 3740 {lab=WL13}
N 9560 3540 9490 3540 {lab=BL30}
N 9640 3540 9710 3540 {lab=BLB30}
C {sram512_bitcell.sym} 9920 3640 0 0 {name=xr13c31}
N 9820 3640 9790 3640 {lab=WL13}
N 9790 3640 9790 3740 {lab=WL13}
N 9880 3540 9810 3540 {lab=BL31}
N 9960 3540 10030 3540 {lab=BLB31}
N -300 3740 9790 3740 {lab=WL13}
C {devices/ipin.sym} -300 3740 0 0 {name=pWL13 lab=WL13}
C {sram512_bitcell.sym} 0 3920 0 0 {name=xr14c0}
N -100 3920 -130 3920 {lab=WL14}
N -130 3920 -130 4020 {lab=WL14}
N -40 3820 -110 3820 {lab=BL0}
N 40 3820 110 3820 {lab=BLB0}
C {sram512_bitcell.sym} 320 3920 0 0 {name=xr14c1}
N 220 3920 190 3920 {lab=WL14}
N 190 3920 190 4020 {lab=WL14}
N 280 3820 210 3820 {lab=BL1}
N 360 3820 430 3820 {lab=BLB1}
C {sram512_bitcell.sym} 640 3920 0 0 {name=xr14c2}
N 540 3920 510 3920 {lab=WL14}
N 510 3920 510 4020 {lab=WL14}
N 600 3820 530 3820 {lab=BL2}
N 680 3820 750 3820 {lab=BLB2}
C {sram512_bitcell.sym} 960 3920 0 0 {name=xr14c3}
N 860 3920 830 3920 {lab=WL14}
N 830 3920 830 4020 {lab=WL14}
N 920 3820 850 3820 {lab=BL3}
N 1000 3820 1070 3820 {lab=BLB3}
C {sram512_bitcell.sym} 1280 3920 0 0 {name=xr14c4}
N 1180 3920 1150 3920 {lab=WL14}
N 1150 3920 1150 4020 {lab=WL14}
N 1240 3820 1170 3820 {lab=BL4}
N 1320 3820 1390 3820 {lab=BLB4}
C {sram512_bitcell.sym} 1600 3920 0 0 {name=xr14c5}
N 1500 3920 1470 3920 {lab=WL14}
N 1470 3920 1470 4020 {lab=WL14}
N 1560 3820 1490 3820 {lab=BL5}
N 1640 3820 1710 3820 {lab=BLB5}
C {sram512_bitcell.sym} 1920 3920 0 0 {name=xr14c6}
N 1820 3920 1790 3920 {lab=WL14}
N 1790 3920 1790 4020 {lab=WL14}
N 1880 3820 1810 3820 {lab=BL6}
N 1960 3820 2030 3820 {lab=BLB6}
C {sram512_bitcell.sym} 2240 3920 0 0 {name=xr14c7}
N 2140 3920 2110 3920 {lab=WL14}
N 2110 3920 2110 4020 {lab=WL14}
N 2200 3820 2130 3820 {lab=BL7}
N 2280 3820 2350 3820 {lab=BLB7}
C {sram512_bitcell.sym} 2560 3920 0 0 {name=xr14c8}
N 2460 3920 2430 3920 {lab=WL14}
N 2430 3920 2430 4020 {lab=WL14}
N 2520 3820 2450 3820 {lab=BL8}
N 2600 3820 2670 3820 {lab=BLB8}
C {sram512_bitcell.sym} 2880 3920 0 0 {name=xr14c9}
N 2780 3920 2750 3920 {lab=WL14}
N 2750 3920 2750 4020 {lab=WL14}
N 2840 3820 2770 3820 {lab=BL9}
N 2920 3820 2990 3820 {lab=BLB9}
C {sram512_bitcell.sym} 3200 3920 0 0 {name=xr14c10}
N 3100 3920 3070 3920 {lab=WL14}
N 3070 3920 3070 4020 {lab=WL14}
N 3160 3820 3090 3820 {lab=BL10}
N 3240 3820 3310 3820 {lab=BLB10}
C {sram512_bitcell.sym} 3520 3920 0 0 {name=xr14c11}
N 3420 3920 3390 3920 {lab=WL14}
N 3390 3920 3390 4020 {lab=WL14}
N 3480 3820 3410 3820 {lab=BL11}
N 3560 3820 3630 3820 {lab=BLB11}
C {sram512_bitcell.sym} 3840 3920 0 0 {name=xr14c12}
N 3740 3920 3710 3920 {lab=WL14}
N 3710 3920 3710 4020 {lab=WL14}
N 3800 3820 3730 3820 {lab=BL12}
N 3880 3820 3950 3820 {lab=BLB12}
C {sram512_bitcell.sym} 4160 3920 0 0 {name=xr14c13}
N 4060 3920 4030 3920 {lab=WL14}
N 4030 3920 4030 4020 {lab=WL14}
N 4120 3820 4050 3820 {lab=BL13}
N 4200 3820 4270 3820 {lab=BLB13}
C {sram512_bitcell.sym} 4480 3920 0 0 {name=xr14c14}
N 4380 3920 4350 3920 {lab=WL14}
N 4350 3920 4350 4020 {lab=WL14}
N 4440 3820 4370 3820 {lab=BL14}
N 4520 3820 4590 3820 {lab=BLB14}
C {sram512_bitcell.sym} 4800 3920 0 0 {name=xr14c15}
N 4700 3920 4670 3920 {lab=WL14}
N 4670 3920 4670 4020 {lab=WL14}
N 4760 3820 4690 3820 {lab=BL15}
N 4840 3820 4910 3820 {lab=BLB15}
C {sram512_bitcell.sym} 5120 3920 0 0 {name=xr14c16}
N 5020 3920 4990 3920 {lab=WL14}
N 4990 3920 4990 4020 {lab=WL14}
N 5080 3820 5010 3820 {lab=BL16}
N 5160 3820 5230 3820 {lab=BLB16}
C {sram512_bitcell.sym} 5440 3920 0 0 {name=xr14c17}
N 5340 3920 5310 3920 {lab=WL14}
N 5310 3920 5310 4020 {lab=WL14}
N 5400 3820 5330 3820 {lab=BL17}
N 5480 3820 5550 3820 {lab=BLB17}
C {sram512_bitcell.sym} 5760 3920 0 0 {name=xr14c18}
N 5660 3920 5630 3920 {lab=WL14}
N 5630 3920 5630 4020 {lab=WL14}
N 5720 3820 5650 3820 {lab=BL18}
N 5800 3820 5870 3820 {lab=BLB18}
C {sram512_bitcell.sym} 6080 3920 0 0 {name=xr14c19}
N 5980 3920 5950 3920 {lab=WL14}
N 5950 3920 5950 4020 {lab=WL14}
N 6040 3820 5970 3820 {lab=BL19}
N 6120 3820 6190 3820 {lab=BLB19}
C {sram512_bitcell.sym} 6400 3920 0 0 {name=xr14c20}
N 6300 3920 6270 3920 {lab=WL14}
N 6270 3920 6270 4020 {lab=WL14}
N 6360 3820 6290 3820 {lab=BL20}
N 6440 3820 6510 3820 {lab=BLB20}
C {sram512_bitcell.sym} 6720 3920 0 0 {name=xr14c21}
N 6620 3920 6590 3920 {lab=WL14}
N 6590 3920 6590 4020 {lab=WL14}
N 6680 3820 6610 3820 {lab=BL21}
N 6760 3820 6830 3820 {lab=BLB21}
C {sram512_bitcell.sym} 7040 3920 0 0 {name=xr14c22}
N 6940 3920 6910 3920 {lab=WL14}
N 6910 3920 6910 4020 {lab=WL14}
N 7000 3820 6930 3820 {lab=BL22}
N 7080 3820 7150 3820 {lab=BLB22}
C {sram512_bitcell.sym} 7360 3920 0 0 {name=xr14c23}
N 7260 3920 7230 3920 {lab=WL14}
N 7230 3920 7230 4020 {lab=WL14}
N 7320 3820 7250 3820 {lab=BL23}
N 7400 3820 7470 3820 {lab=BLB23}
C {sram512_bitcell.sym} 7680 3920 0 0 {name=xr14c24}
N 7580 3920 7550 3920 {lab=WL14}
N 7550 3920 7550 4020 {lab=WL14}
N 7640 3820 7570 3820 {lab=BL24}
N 7720 3820 7790 3820 {lab=BLB24}
C {sram512_bitcell.sym} 8000 3920 0 0 {name=xr14c25}
N 7900 3920 7870 3920 {lab=WL14}
N 7870 3920 7870 4020 {lab=WL14}
N 7960 3820 7890 3820 {lab=BL25}
N 8040 3820 8110 3820 {lab=BLB25}
C {sram512_bitcell.sym} 8320 3920 0 0 {name=xr14c26}
N 8220 3920 8190 3920 {lab=WL14}
N 8190 3920 8190 4020 {lab=WL14}
N 8280 3820 8210 3820 {lab=BL26}
N 8360 3820 8430 3820 {lab=BLB26}
C {sram512_bitcell.sym} 8640 3920 0 0 {name=xr14c27}
N 8540 3920 8510 3920 {lab=WL14}
N 8510 3920 8510 4020 {lab=WL14}
N 8600 3820 8530 3820 {lab=BL27}
N 8680 3820 8750 3820 {lab=BLB27}
C {sram512_bitcell.sym} 8960 3920 0 0 {name=xr14c28}
N 8860 3920 8830 3920 {lab=WL14}
N 8830 3920 8830 4020 {lab=WL14}
N 8920 3820 8850 3820 {lab=BL28}
N 9000 3820 9070 3820 {lab=BLB28}
C {sram512_bitcell.sym} 9280 3920 0 0 {name=xr14c29}
N 9180 3920 9150 3920 {lab=WL14}
N 9150 3920 9150 4020 {lab=WL14}
N 9240 3820 9170 3820 {lab=BL29}
N 9320 3820 9390 3820 {lab=BLB29}
C {sram512_bitcell.sym} 9600 3920 0 0 {name=xr14c30}
N 9500 3920 9470 3920 {lab=WL14}
N 9470 3920 9470 4020 {lab=WL14}
N 9560 3820 9490 3820 {lab=BL30}
N 9640 3820 9710 3820 {lab=BLB30}
C {sram512_bitcell.sym} 9920 3920 0 0 {name=xr14c31}
N 9820 3920 9790 3920 {lab=WL14}
N 9790 3920 9790 4020 {lab=WL14}
N 9880 3820 9810 3820 {lab=BL31}
N 9960 3820 10030 3820 {lab=BLB31}
N -300 4020 9790 4020 {lab=WL14}
C {devices/ipin.sym} -300 4020 0 0 {name=pWL14 lab=WL14}
C {sram512_bitcell.sym} 0 4200 0 0 {name=xr15c0}
N -100 4200 -130 4200 {lab=WL15}
N -130 4200 -130 4300 {lab=WL15}
N -40 4100 -110 4100 {lab=BL0}
N 40 4100 110 4100 {lab=BLB0}
C {sram512_bitcell.sym} 320 4200 0 0 {name=xr15c1}
N 220 4200 190 4200 {lab=WL15}
N 190 4200 190 4300 {lab=WL15}
N 280 4100 210 4100 {lab=BL1}
N 360 4100 430 4100 {lab=BLB1}
C {sram512_bitcell.sym} 640 4200 0 0 {name=xr15c2}
N 540 4200 510 4200 {lab=WL15}
N 510 4200 510 4300 {lab=WL15}
N 600 4100 530 4100 {lab=BL2}
N 680 4100 750 4100 {lab=BLB2}
C {sram512_bitcell.sym} 960 4200 0 0 {name=xr15c3}
N 860 4200 830 4200 {lab=WL15}
N 830 4200 830 4300 {lab=WL15}
N 920 4100 850 4100 {lab=BL3}
N 1000 4100 1070 4100 {lab=BLB3}
C {sram512_bitcell.sym} 1280 4200 0 0 {name=xr15c4}
N 1180 4200 1150 4200 {lab=WL15}
N 1150 4200 1150 4300 {lab=WL15}
N 1240 4100 1170 4100 {lab=BL4}
N 1320 4100 1390 4100 {lab=BLB4}
C {sram512_bitcell.sym} 1600 4200 0 0 {name=xr15c5}
N 1500 4200 1470 4200 {lab=WL15}
N 1470 4200 1470 4300 {lab=WL15}
N 1560 4100 1490 4100 {lab=BL5}
N 1640 4100 1710 4100 {lab=BLB5}
C {sram512_bitcell.sym} 1920 4200 0 0 {name=xr15c6}
N 1820 4200 1790 4200 {lab=WL15}
N 1790 4200 1790 4300 {lab=WL15}
N 1880 4100 1810 4100 {lab=BL6}
N 1960 4100 2030 4100 {lab=BLB6}
C {sram512_bitcell.sym} 2240 4200 0 0 {name=xr15c7}
N 2140 4200 2110 4200 {lab=WL15}
N 2110 4200 2110 4300 {lab=WL15}
N 2200 4100 2130 4100 {lab=BL7}
N 2280 4100 2350 4100 {lab=BLB7}
C {sram512_bitcell.sym} 2560 4200 0 0 {name=xr15c8}
N 2460 4200 2430 4200 {lab=WL15}
N 2430 4200 2430 4300 {lab=WL15}
N 2520 4100 2450 4100 {lab=BL8}
N 2600 4100 2670 4100 {lab=BLB8}
C {sram512_bitcell.sym} 2880 4200 0 0 {name=xr15c9}
N 2780 4200 2750 4200 {lab=WL15}
N 2750 4200 2750 4300 {lab=WL15}
N 2840 4100 2770 4100 {lab=BL9}
N 2920 4100 2990 4100 {lab=BLB9}
C {sram512_bitcell.sym} 3200 4200 0 0 {name=xr15c10}
N 3100 4200 3070 4200 {lab=WL15}
N 3070 4200 3070 4300 {lab=WL15}
N 3160 4100 3090 4100 {lab=BL10}
N 3240 4100 3310 4100 {lab=BLB10}
C {sram512_bitcell.sym} 3520 4200 0 0 {name=xr15c11}
N 3420 4200 3390 4200 {lab=WL15}
N 3390 4200 3390 4300 {lab=WL15}
N 3480 4100 3410 4100 {lab=BL11}
N 3560 4100 3630 4100 {lab=BLB11}
C {sram512_bitcell.sym} 3840 4200 0 0 {name=xr15c12}
N 3740 4200 3710 4200 {lab=WL15}
N 3710 4200 3710 4300 {lab=WL15}
N 3800 4100 3730 4100 {lab=BL12}
N 3880 4100 3950 4100 {lab=BLB12}
C {sram512_bitcell.sym} 4160 4200 0 0 {name=xr15c13}
N 4060 4200 4030 4200 {lab=WL15}
N 4030 4200 4030 4300 {lab=WL15}
N 4120 4100 4050 4100 {lab=BL13}
N 4200 4100 4270 4100 {lab=BLB13}
C {sram512_bitcell.sym} 4480 4200 0 0 {name=xr15c14}
N 4380 4200 4350 4200 {lab=WL15}
N 4350 4200 4350 4300 {lab=WL15}
N 4440 4100 4370 4100 {lab=BL14}
N 4520 4100 4590 4100 {lab=BLB14}
C {sram512_bitcell.sym} 4800 4200 0 0 {name=xr15c15}
N 4700 4200 4670 4200 {lab=WL15}
N 4670 4200 4670 4300 {lab=WL15}
N 4760 4100 4690 4100 {lab=BL15}
N 4840 4100 4910 4100 {lab=BLB15}
C {sram512_bitcell.sym} 5120 4200 0 0 {name=xr15c16}
N 5020 4200 4990 4200 {lab=WL15}
N 4990 4200 4990 4300 {lab=WL15}
N 5080 4100 5010 4100 {lab=BL16}
N 5160 4100 5230 4100 {lab=BLB16}
C {sram512_bitcell.sym} 5440 4200 0 0 {name=xr15c17}
N 5340 4200 5310 4200 {lab=WL15}
N 5310 4200 5310 4300 {lab=WL15}
N 5400 4100 5330 4100 {lab=BL17}
N 5480 4100 5550 4100 {lab=BLB17}
C {sram512_bitcell.sym} 5760 4200 0 0 {name=xr15c18}
N 5660 4200 5630 4200 {lab=WL15}
N 5630 4200 5630 4300 {lab=WL15}
N 5720 4100 5650 4100 {lab=BL18}
N 5800 4100 5870 4100 {lab=BLB18}
C {sram512_bitcell.sym} 6080 4200 0 0 {name=xr15c19}
N 5980 4200 5950 4200 {lab=WL15}
N 5950 4200 5950 4300 {lab=WL15}
N 6040 4100 5970 4100 {lab=BL19}
N 6120 4100 6190 4100 {lab=BLB19}
C {sram512_bitcell.sym} 6400 4200 0 0 {name=xr15c20}
N 6300 4200 6270 4200 {lab=WL15}
N 6270 4200 6270 4300 {lab=WL15}
N 6360 4100 6290 4100 {lab=BL20}
N 6440 4100 6510 4100 {lab=BLB20}
C {sram512_bitcell.sym} 6720 4200 0 0 {name=xr15c21}
N 6620 4200 6590 4200 {lab=WL15}
N 6590 4200 6590 4300 {lab=WL15}
N 6680 4100 6610 4100 {lab=BL21}
N 6760 4100 6830 4100 {lab=BLB21}
C {sram512_bitcell.sym} 7040 4200 0 0 {name=xr15c22}
N 6940 4200 6910 4200 {lab=WL15}
N 6910 4200 6910 4300 {lab=WL15}
N 7000 4100 6930 4100 {lab=BL22}
N 7080 4100 7150 4100 {lab=BLB22}
C {sram512_bitcell.sym} 7360 4200 0 0 {name=xr15c23}
N 7260 4200 7230 4200 {lab=WL15}
N 7230 4200 7230 4300 {lab=WL15}
N 7320 4100 7250 4100 {lab=BL23}
N 7400 4100 7470 4100 {lab=BLB23}
C {sram512_bitcell.sym} 7680 4200 0 0 {name=xr15c24}
N 7580 4200 7550 4200 {lab=WL15}
N 7550 4200 7550 4300 {lab=WL15}
N 7640 4100 7570 4100 {lab=BL24}
N 7720 4100 7790 4100 {lab=BLB24}
C {sram512_bitcell.sym} 8000 4200 0 0 {name=xr15c25}
N 7900 4200 7870 4200 {lab=WL15}
N 7870 4200 7870 4300 {lab=WL15}
N 7960 4100 7890 4100 {lab=BL25}
N 8040 4100 8110 4100 {lab=BLB25}
C {sram512_bitcell.sym} 8320 4200 0 0 {name=xr15c26}
N 8220 4200 8190 4200 {lab=WL15}
N 8190 4200 8190 4300 {lab=WL15}
N 8280 4100 8210 4100 {lab=BL26}
N 8360 4100 8430 4100 {lab=BLB26}
C {sram512_bitcell.sym} 8640 4200 0 0 {name=xr15c27}
N 8540 4200 8510 4200 {lab=WL15}
N 8510 4200 8510 4300 {lab=WL15}
N 8600 4100 8530 4100 {lab=BL27}
N 8680 4100 8750 4100 {lab=BLB27}
C {sram512_bitcell.sym} 8960 4200 0 0 {name=xr15c28}
N 8860 4200 8830 4200 {lab=WL15}
N 8830 4200 8830 4300 {lab=WL15}
N 8920 4100 8850 4100 {lab=BL28}
N 9000 4100 9070 4100 {lab=BLB28}
C {sram512_bitcell.sym} 9280 4200 0 0 {name=xr15c29}
N 9180 4200 9150 4200 {lab=WL15}
N 9150 4200 9150 4300 {lab=WL15}
N 9240 4100 9170 4100 {lab=BL29}
N 9320 4100 9390 4100 {lab=BLB29}
C {sram512_bitcell.sym} 9600 4200 0 0 {name=xr15c30}
N 9500 4200 9470 4200 {lab=WL15}
N 9470 4200 9470 4300 {lab=WL15}
N 9560 4100 9490 4100 {lab=BL30}
N 9640 4100 9710 4100 {lab=BLB30}
C {sram512_bitcell.sym} 9920 4200 0 0 {name=xr15c31}
N 9820 4200 9790 4200 {lab=WL15}
N 9790 4200 9790 4300 {lab=WL15}
N 9880 4100 9810 4100 {lab=BL31}
N 9960 4100 10030 4100 {lab=BLB31}
N -300 4300 9790 4300 {lab=WL15}
C {devices/ipin.sym} -300 4300 0 0 {name=pWL15 lab=WL15}
N -110 -240 -110 4100 {lab=BL0}
C {devices/iopin.sym} -110 -240 0 0 {name=pBL0 lab=BL0}
N 110 -240 110 4100 {lab=BLB0}
C {devices/iopin.sym} 110 -240 0 0 {name=pBLB0 lab=BLB0}
N 210 -240 210 4100 {lab=BL1}
C {devices/iopin.sym} 210 -240 0 0 {name=pBL1 lab=BL1}
N 430 -240 430 4100 {lab=BLB1}
C {devices/iopin.sym} 430 -240 0 0 {name=pBLB1 lab=BLB1}
N 530 -240 530 4100 {lab=BL2}
C {devices/iopin.sym} 530 -240 0 0 {name=pBL2 lab=BL2}
N 750 -240 750 4100 {lab=BLB2}
C {devices/iopin.sym} 750 -240 0 0 {name=pBLB2 lab=BLB2}
N 850 -240 850 4100 {lab=BL3}
C {devices/iopin.sym} 850 -240 0 0 {name=pBL3 lab=BL3}
N 1070 -240 1070 4100 {lab=BLB3}
C {devices/iopin.sym} 1070 -240 0 0 {name=pBLB3 lab=BLB3}
N 1170 -240 1170 4100 {lab=BL4}
C {devices/iopin.sym} 1170 -240 0 0 {name=pBL4 lab=BL4}
N 1390 -240 1390 4100 {lab=BLB4}
C {devices/iopin.sym} 1390 -240 0 0 {name=pBLB4 lab=BLB4}
N 1490 -240 1490 4100 {lab=BL5}
C {devices/iopin.sym} 1490 -240 0 0 {name=pBL5 lab=BL5}
N 1710 -240 1710 4100 {lab=BLB5}
C {devices/iopin.sym} 1710 -240 0 0 {name=pBLB5 lab=BLB5}
N 1810 -240 1810 4100 {lab=BL6}
C {devices/iopin.sym} 1810 -240 0 0 {name=pBL6 lab=BL6}
N 2030 -240 2030 4100 {lab=BLB6}
C {devices/iopin.sym} 2030 -240 0 0 {name=pBLB6 lab=BLB6}
N 2130 -240 2130 4100 {lab=BL7}
C {devices/iopin.sym} 2130 -240 0 0 {name=pBL7 lab=BL7}
N 2350 -240 2350 4100 {lab=BLB7}
C {devices/iopin.sym} 2350 -240 0 0 {name=pBLB7 lab=BLB7}
N 2450 -240 2450 4100 {lab=BL8}
C {devices/iopin.sym} 2450 -240 0 0 {name=pBL8 lab=BL8}
N 2670 -240 2670 4100 {lab=BLB8}
C {devices/iopin.sym} 2670 -240 0 0 {name=pBLB8 lab=BLB8}
N 2770 -240 2770 4100 {lab=BL9}
C {devices/iopin.sym} 2770 -240 0 0 {name=pBL9 lab=BL9}
N 2990 -240 2990 4100 {lab=BLB9}
C {devices/iopin.sym} 2990 -240 0 0 {name=pBLB9 lab=BLB9}
N 3090 -240 3090 4100 {lab=BL10}
C {devices/iopin.sym} 3090 -240 0 0 {name=pBL10 lab=BL10}
N 3310 -240 3310 4100 {lab=BLB10}
C {devices/iopin.sym} 3310 -240 0 0 {name=pBLB10 lab=BLB10}
N 3410 -240 3410 4100 {lab=BL11}
C {devices/iopin.sym} 3410 -240 0 0 {name=pBL11 lab=BL11}
N 3630 -240 3630 4100 {lab=BLB11}
C {devices/iopin.sym} 3630 -240 0 0 {name=pBLB11 lab=BLB11}
N 3730 -240 3730 4100 {lab=BL12}
C {devices/iopin.sym} 3730 -240 0 0 {name=pBL12 lab=BL12}
N 3950 -240 3950 4100 {lab=BLB12}
C {devices/iopin.sym} 3950 -240 0 0 {name=pBLB12 lab=BLB12}
N 4050 -240 4050 4100 {lab=BL13}
C {devices/iopin.sym} 4050 -240 0 0 {name=pBL13 lab=BL13}
N 4270 -240 4270 4100 {lab=BLB13}
C {devices/iopin.sym} 4270 -240 0 0 {name=pBLB13 lab=BLB13}
N 4370 -240 4370 4100 {lab=BL14}
C {devices/iopin.sym} 4370 -240 0 0 {name=pBL14 lab=BL14}
N 4590 -240 4590 4100 {lab=BLB14}
C {devices/iopin.sym} 4590 -240 0 0 {name=pBLB14 lab=BLB14}
N 4690 -240 4690 4100 {lab=BL15}
C {devices/iopin.sym} 4690 -240 0 0 {name=pBL15 lab=BL15}
N 4910 -240 4910 4100 {lab=BLB15}
C {devices/iopin.sym} 4910 -240 0 0 {name=pBLB15 lab=BLB15}
N 5010 -240 5010 4100 {lab=BL16}
C {devices/iopin.sym} 5010 -240 0 0 {name=pBL16 lab=BL16}
N 5230 -240 5230 4100 {lab=BLB16}
C {devices/iopin.sym} 5230 -240 0 0 {name=pBLB16 lab=BLB16}
N 5330 -240 5330 4100 {lab=BL17}
C {devices/iopin.sym} 5330 -240 0 0 {name=pBL17 lab=BL17}
N 5550 -240 5550 4100 {lab=BLB17}
C {devices/iopin.sym} 5550 -240 0 0 {name=pBLB17 lab=BLB17}
N 5650 -240 5650 4100 {lab=BL18}
C {devices/iopin.sym} 5650 -240 0 0 {name=pBL18 lab=BL18}
N 5870 -240 5870 4100 {lab=BLB18}
C {devices/iopin.sym} 5870 -240 0 0 {name=pBLB18 lab=BLB18}
N 5970 -240 5970 4100 {lab=BL19}
C {devices/iopin.sym} 5970 -240 0 0 {name=pBL19 lab=BL19}
N 6190 -240 6190 4100 {lab=BLB19}
C {devices/iopin.sym} 6190 -240 0 0 {name=pBLB19 lab=BLB19}
N 6290 -240 6290 4100 {lab=BL20}
C {devices/iopin.sym} 6290 -240 0 0 {name=pBL20 lab=BL20}
N 6510 -240 6510 4100 {lab=BLB20}
C {devices/iopin.sym} 6510 -240 0 0 {name=pBLB20 lab=BLB20}
N 6610 -240 6610 4100 {lab=BL21}
C {devices/iopin.sym} 6610 -240 0 0 {name=pBL21 lab=BL21}
N 6830 -240 6830 4100 {lab=BLB21}
C {devices/iopin.sym} 6830 -240 0 0 {name=pBLB21 lab=BLB21}
N 6930 -240 6930 4100 {lab=BL22}
C {devices/iopin.sym} 6930 -240 0 0 {name=pBL22 lab=BL22}
N 7150 -240 7150 4100 {lab=BLB22}
C {devices/iopin.sym} 7150 -240 0 0 {name=pBLB22 lab=BLB22}
N 7250 -240 7250 4100 {lab=BL23}
C {devices/iopin.sym} 7250 -240 0 0 {name=pBL23 lab=BL23}
N 7470 -240 7470 4100 {lab=BLB23}
C {devices/iopin.sym} 7470 -240 0 0 {name=pBLB23 lab=BLB23}
N 7570 -240 7570 4100 {lab=BL24}
C {devices/iopin.sym} 7570 -240 0 0 {name=pBL24 lab=BL24}
N 7790 -240 7790 4100 {lab=BLB24}
C {devices/iopin.sym} 7790 -240 0 0 {name=pBLB24 lab=BLB24}
N 7890 -240 7890 4100 {lab=BL25}
C {devices/iopin.sym} 7890 -240 0 0 {name=pBL25 lab=BL25}
N 8110 -240 8110 4100 {lab=BLB25}
C {devices/iopin.sym} 8110 -240 0 0 {name=pBLB25 lab=BLB25}
N 8210 -240 8210 4100 {lab=BL26}
C {devices/iopin.sym} 8210 -240 0 0 {name=pBL26 lab=BL26}
N 8430 -240 8430 4100 {lab=BLB26}
C {devices/iopin.sym} 8430 -240 0 0 {name=pBLB26 lab=BLB26}
N 8530 -240 8530 4100 {lab=BL27}
C {devices/iopin.sym} 8530 -240 0 0 {name=pBL27 lab=BL27}
N 8750 -240 8750 4100 {lab=BLB27}
C {devices/iopin.sym} 8750 -240 0 0 {name=pBLB27 lab=BLB27}
N 8850 -240 8850 4100 {lab=BL28}
C {devices/iopin.sym} 8850 -240 0 0 {name=pBL28 lab=BL28}
N 9070 -240 9070 4100 {lab=BLB28}
C {devices/iopin.sym} 9070 -240 0 0 {name=pBLB28 lab=BLB28}
N 9170 -240 9170 4100 {lab=BL29}
C {devices/iopin.sym} 9170 -240 0 0 {name=pBL29 lab=BL29}
N 9390 -240 9390 4100 {lab=BLB29}
C {devices/iopin.sym} 9390 -240 0 0 {name=pBLB29 lab=BLB29}
N 9490 -240 9490 4100 {lab=BL30}
C {devices/iopin.sym} 9490 -240 0 0 {name=pBL30 lab=BL30}
N 9710 -240 9710 4100 {lab=BLB30}
C {devices/iopin.sym} 9710 -240 0 0 {name=pBLB30 lab=BLB30}
N 9810 -240 9810 4100 {lab=BL31}
C {devices/iopin.sym} 9810 -240 0 0 {name=pBL31 lab=BL31}
N 10030 -240 10030 4100 {lab=BLB31}
C {devices/iopin.sym} 10030 -240 0 0 {name=pBLB31 lab=BLB31}
C {devices/iopin.sym} -300 -340 0 0 {name=pVDD lab=VDD}
N -300 -340 -240 -340 {lab=VDD}
C {devices/lab_pin.sym} -240 -340 0 0 {name=l2729 lab=VDD hide_texts=true}
C {devices/iopin.sym} -100 -340 0 0 {name=pVSS lab=VSS}
N -100 -340 -40 -340 {lab=VSS}
C {devices/lab_pin.sym} -40 -340 0 0 {name=l2732 lab=VSS hide_texts=true}
C {devices/lab_pin.sym} 100 -40 0 0 {name=l2733 lab=VDD}
C {devices/lab_pin.sym} 100 40 0 0 {name=l2734 lab=VSS}
C {devices/lab_pin.sym} 420 -40 0 0 {name=l2735 lab=VDD}
C {devices/lab_pin.sym} 420 40 0 0 {name=l2736 lab=VSS}
C {devices/lab_pin.sym} 740 -40 0 0 {name=l2737 lab=VDD}
C {devices/lab_pin.sym} 740 40 0 0 {name=l2738 lab=VSS}
C {devices/lab_pin.sym} 1060 -40 0 0 {name=l2739 lab=VDD}
C {devices/lab_pin.sym} 1060 40 0 0 {name=l2740 lab=VSS}
C {devices/lab_pin.sym} 1380 -40 0 0 {name=l2741 lab=VDD}
C {devices/lab_pin.sym} 1380 40 0 0 {name=l2742 lab=VSS}
C {devices/lab_pin.sym} 1700 -40 0 0 {name=l2743 lab=VDD}
C {devices/lab_pin.sym} 1700 40 0 0 {name=l2744 lab=VSS}
C {devices/lab_pin.sym} 2020 -40 0 0 {name=l2745 lab=VDD}
C {devices/lab_pin.sym} 2020 40 0 0 {name=l2746 lab=VSS}
C {devices/lab_pin.sym} 2340 -40 0 0 {name=l2747 lab=VDD}
C {devices/lab_pin.sym} 2340 40 0 0 {name=l2748 lab=VSS}
C {devices/lab_pin.sym} 2660 -40 0 0 {name=l2749 lab=VDD}
C {devices/lab_pin.sym} 2660 40 0 0 {name=l2750 lab=VSS}
C {devices/lab_pin.sym} 2980 -40 0 0 {name=l2751 lab=VDD}
C {devices/lab_pin.sym} 2980 40 0 0 {name=l2752 lab=VSS}
C {devices/lab_pin.sym} 3300 -40 0 0 {name=l2753 lab=VDD}
C {devices/lab_pin.sym} 3300 40 0 0 {name=l2754 lab=VSS}
C {devices/lab_pin.sym} 3620 -40 0 0 {name=l2755 lab=VDD}
C {devices/lab_pin.sym} 3620 40 0 0 {name=l2756 lab=VSS}
C {devices/lab_pin.sym} 3940 -40 0 0 {name=l2757 lab=VDD}
C {devices/lab_pin.sym} 3940 40 0 0 {name=l2758 lab=VSS}
C {devices/lab_pin.sym} 4260 -40 0 0 {name=l2759 lab=VDD}
C {devices/lab_pin.sym} 4260 40 0 0 {name=l2760 lab=VSS}
C {devices/lab_pin.sym} 4580 -40 0 0 {name=l2761 lab=VDD}
C {devices/lab_pin.sym} 4580 40 0 0 {name=l2762 lab=VSS}
C {devices/lab_pin.sym} 4900 -40 0 0 {name=l2763 lab=VDD}
C {devices/lab_pin.sym} 4900 40 0 0 {name=l2764 lab=VSS}
C {devices/lab_pin.sym} 5220 -40 0 0 {name=l2765 lab=VDD}
C {devices/lab_pin.sym} 5220 40 0 0 {name=l2766 lab=VSS}
C {devices/lab_pin.sym} 5540 -40 0 0 {name=l2767 lab=VDD}
C {devices/lab_pin.sym} 5540 40 0 0 {name=l2768 lab=VSS}
C {devices/lab_pin.sym} 5860 -40 0 0 {name=l2769 lab=VDD}
C {devices/lab_pin.sym} 5860 40 0 0 {name=l2770 lab=VSS}
C {devices/lab_pin.sym} 6180 -40 0 0 {name=l2771 lab=VDD}
C {devices/lab_pin.sym} 6180 40 0 0 {name=l2772 lab=VSS}
C {devices/lab_pin.sym} 6500 -40 0 0 {name=l2773 lab=VDD}
C {devices/lab_pin.sym} 6500 40 0 0 {name=l2774 lab=VSS}
C {devices/lab_pin.sym} 6820 -40 0 0 {name=l2775 lab=VDD}
C {devices/lab_pin.sym} 6820 40 0 0 {name=l2776 lab=VSS}
C {devices/lab_pin.sym} 7140 -40 0 0 {name=l2777 lab=VDD}
C {devices/lab_pin.sym} 7140 40 0 0 {name=l2778 lab=VSS}
C {devices/lab_pin.sym} 7460 -40 0 0 {name=l2779 lab=VDD}
C {devices/lab_pin.sym} 7460 40 0 0 {name=l2780 lab=VSS}
C {devices/lab_pin.sym} 7780 -40 0 0 {name=l2781 lab=VDD}
C {devices/lab_pin.sym} 7780 40 0 0 {name=l2782 lab=VSS}
C {devices/lab_pin.sym} 8100 -40 0 0 {name=l2783 lab=VDD}
C {devices/lab_pin.sym} 8100 40 0 0 {name=l2784 lab=VSS}
C {devices/lab_pin.sym} 8420 -40 0 0 {name=l2785 lab=VDD}
C {devices/lab_pin.sym} 8420 40 0 0 {name=l2786 lab=VSS}
C {devices/lab_pin.sym} 8740 -40 0 0 {name=l2787 lab=VDD}
C {devices/lab_pin.sym} 8740 40 0 0 {name=l2788 lab=VSS}
C {devices/lab_pin.sym} 9060 -40 0 0 {name=l2789 lab=VDD}
C {devices/lab_pin.sym} 9060 40 0 0 {name=l2790 lab=VSS}
C {devices/lab_pin.sym} 9380 -40 0 0 {name=l2791 lab=VDD}
C {devices/lab_pin.sym} 9380 40 0 0 {name=l2792 lab=VSS}
C {devices/lab_pin.sym} 9700 -40 0 0 {name=l2793 lab=VDD}
C {devices/lab_pin.sym} 9700 40 0 0 {name=l2794 lab=VSS}
C {devices/lab_pin.sym} 10020 -40 0 0 {name=l2795 lab=VDD}
C {devices/lab_pin.sym} 10020 40 0 0 {name=l2796 lab=VSS}
C {devices/lab_pin.sym} 100 240 0 0 {name=l2797 lab=VDD}
C {devices/lab_pin.sym} 100 320 0 0 {name=l2798 lab=VSS}
C {devices/lab_pin.sym} 420 240 0 0 {name=l2799 lab=VDD}
C {devices/lab_pin.sym} 420 320 0 0 {name=l2800 lab=VSS}
C {devices/lab_pin.sym} 740 240 0 0 {name=l2801 lab=VDD}
C {devices/lab_pin.sym} 740 320 0 0 {name=l2802 lab=VSS}
C {devices/lab_pin.sym} 1060 240 0 0 {name=l2803 lab=VDD}
C {devices/lab_pin.sym} 1060 320 0 0 {name=l2804 lab=VSS}
C {devices/lab_pin.sym} 1380 240 0 0 {name=l2805 lab=VDD}
C {devices/lab_pin.sym} 1380 320 0 0 {name=l2806 lab=VSS}
C {devices/lab_pin.sym} 1700 240 0 0 {name=l2807 lab=VDD}
C {devices/lab_pin.sym} 1700 320 0 0 {name=l2808 lab=VSS}
C {devices/lab_pin.sym} 2020 240 0 0 {name=l2809 lab=VDD}
C {devices/lab_pin.sym} 2020 320 0 0 {name=l2810 lab=VSS}
C {devices/lab_pin.sym} 2340 240 0 0 {name=l2811 lab=VDD}
C {devices/lab_pin.sym} 2340 320 0 0 {name=l2812 lab=VSS}
C {devices/lab_pin.sym} 2660 240 0 0 {name=l2813 lab=VDD}
C {devices/lab_pin.sym} 2660 320 0 0 {name=l2814 lab=VSS}
C {devices/lab_pin.sym} 2980 240 0 0 {name=l2815 lab=VDD}
C {devices/lab_pin.sym} 2980 320 0 0 {name=l2816 lab=VSS}
C {devices/lab_pin.sym} 3300 240 0 0 {name=l2817 lab=VDD}
C {devices/lab_pin.sym} 3300 320 0 0 {name=l2818 lab=VSS}
C {devices/lab_pin.sym} 3620 240 0 0 {name=l2819 lab=VDD}
C {devices/lab_pin.sym} 3620 320 0 0 {name=l2820 lab=VSS}
C {devices/lab_pin.sym} 3940 240 0 0 {name=l2821 lab=VDD}
C {devices/lab_pin.sym} 3940 320 0 0 {name=l2822 lab=VSS}
C {devices/lab_pin.sym} 4260 240 0 0 {name=l2823 lab=VDD}
C {devices/lab_pin.sym} 4260 320 0 0 {name=l2824 lab=VSS}
C {devices/lab_pin.sym} 4580 240 0 0 {name=l2825 lab=VDD}
C {devices/lab_pin.sym} 4580 320 0 0 {name=l2826 lab=VSS}
C {devices/lab_pin.sym} 4900 240 0 0 {name=l2827 lab=VDD}
C {devices/lab_pin.sym} 4900 320 0 0 {name=l2828 lab=VSS}
C {devices/lab_pin.sym} 5220 240 0 0 {name=l2829 lab=VDD}
C {devices/lab_pin.sym} 5220 320 0 0 {name=l2830 lab=VSS}
C {devices/lab_pin.sym} 5540 240 0 0 {name=l2831 lab=VDD}
C {devices/lab_pin.sym} 5540 320 0 0 {name=l2832 lab=VSS}
C {devices/lab_pin.sym} 5860 240 0 0 {name=l2833 lab=VDD}
C {devices/lab_pin.sym} 5860 320 0 0 {name=l2834 lab=VSS}
C {devices/lab_pin.sym} 6180 240 0 0 {name=l2835 lab=VDD}
C {devices/lab_pin.sym} 6180 320 0 0 {name=l2836 lab=VSS}
C {devices/lab_pin.sym} 6500 240 0 0 {name=l2837 lab=VDD}
C {devices/lab_pin.sym} 6500 320 0 0 {name=l2838 lab=VSS}
C {devices/lab_pin.sym} 6820 240 0 0 {name=l2839 lab=VDD}
C {devices/lab_pin.sym} 6820 320 0 0 {name=l2840 lab=VSS}
C {devices/lab_pin.sym} 7140 240 0 0 {name=l2841 lab=VDD}
C {devices/lab_pin.sym} 7140 320 0 0 {name=l2842 lab=VSS}
C {devices/lab_pin.sym} 7460 240 0 0 {name=l2843 lab=VDD}
C {devices/lab_pin.sym} 7460 320 0 0 {name=l2844 lab=VSS}
C {devices/lab_pin.sym} 7780 240 0 0 {name=l2845 lab=VDD}
C {devices/lab_pin.sym} 7780 320 0 0 {name=l2846 lab=VSS}
C {devices/lab_pin.sym} 8100 240 0 0 {name=l2847 lab=VDD}
C {devices/lab_pin.sym} 8100 320 0 0 {name=l2848 lab=VSS}
C {devices/lab_pin.sym} 8420 240 0 0 {name=l2849 lab=VDD}
C {devices/lab_pin.sym} 8420 320 0 0 {name=l2850 lab=VSS}
C {devices/lab_pin.sym} 8740 240 0 0 {name=l2851 lab=VDD}
C {devices/lab_pin.sym} 8740 320 0 0 {name=l2852 lab=VSS}
C {devices/lab_pin.sym} 9060 240 0 0 {name=l2853 lab=VDD}
C {devices/lab_pin.sym} 9060 320 0 0 {name=l2854 lab=VSS}
C {devices/lab_pin.sym} 9380 240 0 0 {name=l2855 lab=VDD}
C {devices/lab_pin.sym} 9380 320 0 0 {name=l2856 lab=VSS}
C {devices/lab_pin.sym} 9700 240 0 0 {name=l2857 lab=VDD}
C {devices/lab_pin.sym} 9700 320 0 0 {name=l2858 lab=VSS}
C {devices/lab_pin.sym} 10020 240 0 0 {name=l2859 lab=VDD}
C {devices/lab_pin.sym} 10020 320 0 0 {name=l2860 lab=VSS}
C {devices/lab_pin.sym} 100 520 0 0 {name=l2861 lab=VDD}
C {devices/lab_pin.sym} 100 600 0 0 {name=l2862 lab=VSS}
C {devices/lab_pin.sym} 420 520 0 0 {name=l2863 lab=VDD}
C {devices/lab_pin.sym} 420 600 0 0 {name=l2864 lab=VSS}
C {devices/lab_pin.sym} 740 520 0 0 {name=l2865 lab=VDD}
C {devices/lab_pin.sym} 740 600 0 0 {name=l2866 lab=VSS}
C {devices/lab_pin.sym} 1060 520 0 0 {name=l2867 lab=VDD}
C {devices/lab_pin.sym} 1060 600 0 0 {name=l2868 lab=VSS}
C {devices/lab_pin.sym} 1380 520 0 0 {name=l2869 lab=VDD}
C {devices/lab_pin.sym} 1380 600 0 0 {name=l2870 lab=VSS}
C {devices/lab_pin.sym} 1700 520 0 0 {name=l2871 lab=VDD}
C {devices/lab_pin.sym} 1700 600 0 0 {name=l2872 lab=VSS}
C {devices/lab_pin.sym} 2020 520 0 0 {name=l2873 lab=VDD}
C {devices/lab_pin.sym} 2020 600 0 0 {name=l2874 lab=VSS}
C {devices/lab_pin.sym} 2340 520 0 0 {name=l2875 lab=VDD}
C {devices/lab_pin.sym} 2340 600 0 0 {name=l2876 lab=VSS}
C {devices/lab_pin.sym} 2660 520 0 0 {name=l2877 lab=VDD}
C {devices/lab_pin.sym} 2660 600 0 0 {name=l2878 lab=VSS}
C {devices/lab_pin.sym} 2980 520 0 0 {name=l2879 lab=VDD}
C {devices/lab_pin.sym} 2980 600 0 0 {name=l2880 lab=VSS}
C {devices/lab_pin.sym} 3300 520 0 0 {name=l2881 lab=VDD}
C {devices/lab_pin.sym} 3300 600 0 0 {name=l2882 lab=VSS}
C {devices/lab_pin.sym} 3620 520 0 0 {name=l2883 lab=VDD}
C {devices/lab_pin.sym} 3620 600 0 0 {name=l2884 lab=VSS}
C {devices/lab_pin.sym} 3940 520 0 0 {name=l2885 lab=VDD}
C {devices/lab_pin.sym} 3940 600 0 0 {name=l2886 lab=VSS}
C {devices/lab_pin.sym} 4260 520 0 0 {name=l2887 lab=VDD}
C {devices/lab_pin.sym} 4260 600 0 0 {name=l2888 lab=VSS}
C {devices/lab_pin.sym} 4580 520 0 0 {name=l2889 lab=VDD}
C {devices/lab_pin.sym} 4580 600 0 0 {name=l2890 lab=VSS}
C {devices/lab_pin.sym} 4900 520 0 0 {name=l2891 lab=VDD}
C {devices/lab_pin.sym} 4900 600 0 0 {name=l2892 lab=VSS}
C {devices/lab_pin.sym} 5220 520 0 0 {name=l2893 lab=VDD}
C {devices/lab_pin.sym} 5220 600 0 0 {name=l2894 lab=VSS}
C {devices/lab_pin.sym} 5540 520 0 0 {name=l2895 lab=VDD}
C {devices/lab_pin.sym} 5540 600 0 0 {name=l2896 lab=VSS}
C {devices/lab_pin.sym} 5860 520 0 0 {name=l2897 lab=VDD}
C {devices/lab_pin.sym} 5860 600 0 0 {name=l2898 lab=VSS}
C {devices/lab_pin.sym} 6180 520 0 0 {name=l2899 lab=VDD}
C {devices/lab_pin.sym} 6180 600 0 0 {name=l2900 lab=VSS}
C {devices/lab_pin.sym} 6500 520 0 0 {name=l2901 lab=VDD}
C {devices/lab_pin.sym} 6500 600 0 0 {name=l2902 lab=VSS}
C {devices/lab_pin.sym} 6820 520 0 0 {name=l2903 lab=VDD}
C {devices/lab_pin.sym} 6820 600 0 0 {name=l2904 lab=VSS}
C {devices/lab_pin.sym} 7140 520 0 0 {name=l2905 lab=VDD}
C {devices/lab_pin.sym} 7140 600 0 0 {name=l2906 lab=VSS}
C {devices/lab_pin.sym} 7460 520 0 0 {name=l2907 lab=VDD}
C {devices/lab_pin.sym} 7460 600 0 0 {name=l2908 lab=VSS}
C {devices/lab_pin.sym} 7780 520 0 0 {name=l2909 lab=VDD}
C {devices/lab_pin.sym} 7780 600 0 0 {name=l2910 lab=VSS}
C {devices/lab_pin.sym} 8100 520 0 0 {name=l2911 lab=VDD}
C {devices/lab_pin.sym} 8100 600 0 0 {name=l2912 lab=VSS}
C {devices/lab_pin.sym} 8420 520 0 0 {name=l2913 lab=VDD}
C {devices/lab_pin.sym} 8420 600 0 0 {name=l2914 lab=VSS}
C {devices/lab_pin.sym} 8740 520 0 0 {name=l2915 lab=VDD}
C {devices/lab_pin.sym} 8740 600 0 0 {name=l2916 lab=VSS}
C {devices/lab_pin.sym} 9060 520 0 0 {name=l2917 lab=VDD}
C {devices/lab_pin.sym} 9060 600 0 0 {name=l2918 lab=VSS}
C {devices/lab_pin.sym} 9380 520 0 0 {name=l2919 lab=VDD}
C {devices/lab_pin.sym} 9380 600 0 0 {name=l2920 lab=VSS}
C {devices/lab_pin.sym} 9700 520 0 0 {name=l2921 lab=VDD}
C {devices/lab_pin.sym} 9700 600 0 0 {name=l2922 lab=VSS}
C {devices/lab_pin.sym} 10020 520 0 0 {name=l2923 lab=VDD}
C {devices/lab_pin.sym} 10020 600 0 0 {name=l2924 lab=VSS}
C {devices/lab_pin.sym} 100 800 0 0 {name=l2925 lab=VDD}
C {devices/lab_pin.sym} 100 880 0 0 {name=l2926 lab=VSS}
C {devices/lab_pin.sym} 420 800 0 0 {name=l2927 lab=VDD}
C {devices/lab_pin.sym} 420 880 0 0 {name=l2928 lab=VSS}
C {devices/lab_pin.sym} 740 800 0 0 {name=l2929 lab=VDD}
C {devices/lab_pin.sym} 740 880 0 0 {name=l2930 lab=VSS}
C {devices/lab_pin.sym} 1060 800 0 0 {name=l2931 lab=VDD}
C {devices/lab_pin.sym} 1060 880 0 0 {name=l2932 lab=VSS}
C {devices/lab_pin.sym} 1380 800 0 0 {name=l2933 lab=VDD}
C {devices/lab_pin.sym} 1380 880 0 0 {name=l2934 lab=VSS}
C {devices/lab_pin.sym} 1700 800 0 0 {name=l2935 lab=VDD}
C {devices/lab_pin.sym} 1700 880 0 0 {name=l2936 lab=VSS}
C {devices/lab_pin.sym} 2020 800 0 0 {name=l2937 lab=VDD}
C {devices/lab_pin.sym} 2020 880 0 0 {name=l2938 lab=VSS}
C {devices/lab_pin.sym} 2340 800 0 0 {name=l2939 lab=VDD}
C {devices/lab_pin.sym} 2340 880 0 0 {name=l2940 lab=VSS}
C {devices/lab_pin.sym} 2660 800 0 0 {name=l2941 lab=VDD}
C {devices/lab_pin.sym} 2660 880 0 0 {name=l2942 lab=VSS}
C {devices/lab_pin.sym} 2980 800 0 0 {name=l2943 lab=VDD}
C {devices/lab_pin.sym} 2980 880 0 0 {name=l2944 lab=VSS}
C {devices/lab_pin.sym} 3300 800 0 0 {name=l2945 lab=VDD}
C {devices/lab_pin.sym} 3300 880 0 0 {name=l2946 lab=VSS}
C {devices/lab_pin.sym} 3620 800 0 0 {name=l2947 lab=VDD}
C {devices/lab_pin.sym} 3620 880 0 0 {name=l2948 lab=VSS}
C {devices/lab_pin.sym} 3940 800 0 0 {name=l2949 lab=VDD}
C {devices/lab_pin.sym} 3940 880 0 0 {name=l2950 lab=VSS}
C {devices/lab_pin.sym} 4260 800 0 0 {name=l2951 lab=VDD}
C {devices/lab_pin.sym} 4260 880 0 0 {name=l2952 lab=VSS}
C {devices/lab_pin.sym} 4580 800 0 0 {name=l2953 lab=VDD}
C {devices/lab_pin.sym} 4580 880 0 0 {name=l2954 lab=VSS}
C {devices/lab_pin.sym} 4900 800 0 0 {name=l2955 lab=VDD}
C {devices/lab_pin.sym} 4900 880 0 0 {name=l2956 lab=VSS}
C {devices/lab_pin.sym} 5220 800 0 0 {name=l2957 lab=VDD}
C {devices/lab_pin.sym} 5220 880 0 0 {name=l2958 lab=VSS}
C {devices/lab_pin.sym} 5540 800 0 0 {name=l2959 lab=VDD}
C {devices/lab_pin.sym} 5540 880 0 0 {name=l2960 lab=VSS}
C {devices/lab_pin.sym} 5860 800 0 0 {name=l2961 lab=VDD}
C {devices/lab_pin.sym} 5860 880 0 0 {name=l2962 lab=VSS}
C {devices/lab_pin.sym} 6180 800 0 0 {name=l2963 lab=VDD}
C {devices/lab_pin.sym} 6180 880 0 0 {name=l2964 lab=VSS}
C {devices/lab_pin.sym} 6500 800 0 0 {name=l2965 lab=VDD}
C {devices/lab_pin.sym} 6500 880 0 0 {name=l2966 lab=VSS}
C {devices/lab_pin.sym} 6820 800 0 0 {name=l2967 lab=VDD}
C {devices/lab_pin.sym} 6820 880 0 0 {name=l2968 lab=VSS}
C {devices/lab_pin.sym} 7140 800 0 0 {name=l2969 lab=VDD}
C {devices/lab_pin.sym} 7140 880 0 0 {name=l2970 lab=VSS}
C {devices/lab_pin.sym} 7460 800 0 0 {name=l2971 lab=VDD}
C {devices/lab_pin.sym} 7460 880 0 0 {name=l2972 lab=VSS}
C {devices/lab_pin.sym} 7780 800 0 0 {name=l2973 lab=VDD}
C {devices/lab_pin.sym} 7780 880 0 0 {name=l2974 lab=VSS}
C {devices/lab_pin.sym} 8100 800 0 0 {name=l2975 lab=VDD}
C {devices/lab_pin.sym} 8100 880 0 0 {name=l2976 lab=VSS}
C {devices/lab_pin.sym} 8420 800 0 0 {name=l2977 lab=VDD}
C {devices/lab_pin.sym} 8420 880 0 0 {name=l2978 lab=VSS}
C {devices/lab_pin.sym} 8740 800 0 0 {name=l2979 lab=VDD}
C {devices/lab_pin.sym} 8740 880 0 0 {name=l2980 lab=VSS}
C {devices/lab_pin.sym} 9060 800 0 0 {name=l2981 lab=VDD}
C {devices/lab_pin.sym} 9060 880 0 0 {name=l2982 lab=VSS}
C {devices/lab_pin.sym} 9380 800 0 0 {name=l2983 lab=VDD}
C {devices/lab_pin.sym} 9380 880 0 0 {name=l2984 lab=VSS}
C {devices/lab_pin.sym} 9700 800 0 0 {name=l2985 lab=VDD}
C {devices/lab_pin.sym} 9700 880 0 0 {name=l2986 lab=VSS}
C {devices/lab_pin.sym} 10020 800 0 0 {name=l2987 lab=VDD}
C {devices/lab_pin.sym} 10020 880 0 0 {name=l2988 lab=VSS}
C {devices/lab_pin.sym} 100 1080 0 0 {name=l2989 lab=VDD}
C {devices/lab_pin.sym} 100 1160 0 0 {name=l2990 lab=VSS}
C {devices/lab_pin.sym} 420 1080 0 0 {name=l2991 lab=VDD}
C {devices/lab_pin.sym} 420 1160 0 0 {name=l2992 lab=VSS}
C {devices/lab_pin.sym} 740 1080 0 0 {name=l2993 lab=VDD}
C {devices/lab_pin.sym} 740 1160 0 0 {name=l2994 lab=VSS}
C {devices/lab_pin.sym} 1060 1080 0 0 {name=l2995 lab=VDD}
C {devices/lab_pin.sym} 1060 1160 0 0 {name=l2996 lab=VSS}
C {devices/lab_pin.sym} 1380 1080 0 0 {name=l2997 lab=VDD}
C {devices/lab_pin.sym} 1380 1160 0 0 {name=l2998 lab=VSS}
C {devices/lab_pin.sym} 1700 1080 0 0 {name=l2999 lab=VDD}
C {devices/lab_pin.sym} 1700 1160 0 0 {name=l3000 lab=VSS}
C {devices/lab_pin.sym} 2020 1080 0 0 {name=l3001 lab=VDD}
C {devices/lab_pin.sym} 2020 1160 0 0 {name=l3002 lab=VSS}
C {devices/lab_pin.sym} 2340 1080 0 0 {name=l3003 lab=VDD}
C {devices/lab_pin.sym} 2340 1160 0 0 {name=l3004 lab=VSS}
C {devices/lab_pin.sym} 2660 1080 0 0 {name=l3005 lab=VDD}
C {devices/lab_pin.sym} 2660 1160 0 0 {name=l3006 lab=VSS}
C {devices/lab_pin.sym} 2980 1080 0 0 {name=l3007 lab=VDD}
C {devices/lab_pin.sym} 2980 1160 0 0 {name=l3008 lab=VSS}
C {devices/lab_pin.sym} 3300 1080 0 0 {name=l3009 lab=VDD}
C {devices/lab_pin.sym} 3300 1160 0 0 {name=l3010 lab=VSS}
C {devices/lab_pin.sym} 3620 1080 0 0 {name=l3011 lab=VDD}
C {devices/lab_pin.sym} 3620 1160 0 0 {name=l3012 lab=VSS}
C {devices/lab_pin.sym} 3940 1080 0 0 {name=l3013 lab=VDD}
C {devices/lab_pin.sym} 3940 1160 0 0 {name=l3014 lab=VSS}
C {devices/lab_pin.sym} 4260 1080 0 0 {name=l3015 lab=VDD}
C {devices/lab_pin.sym} 4260 1160 0 0 {name=l3016 lab=VSS}
C {devices/lab_pin.sym} 4580 1080 0 0 {name=l3017 lab=VDD}
C {devices/lab_pin.sym} 4580 1160 0 0 {name=l3018 lab=VSS}
C {devices/lab_pin.sym} 4900 1080 0 0 {name=l3019 lab=VDD}
C {devices/lab_pin.sym} 4900 1160 0 0 {name=l3020 lab=VSS}
C {devices/lab_pin.sym} 5220 1080 0 0 {name=l3021 lab=VDD}
C {devices/lab_pin.sym} 5220 1160 0 0 {name=l3022 lab=VSS}
C {devices/lab_pin.sym} 5540 1080 0 0 {name=l3023 lab=VDD}
C {devices/lab_pin.sym} 5540 1160 0 0 {name=l3024 lab=VSS}
C {devices/lab_pin.sym} 5860 1080 0 0 {name=l3025 lab=VDD}
C {devices/lab_pin.sym} 5860 1160 0 0 {name=l3026 lab=VSS}
C {devices/lab_pin.sym} 6180 1080 0 0 {name=l3027 lab=VDD}
C {devices/lab_pin.sym} 6180 1160 0 0 {name=l3028 lab=VSS}
C {devices/lab_pin.sym} 6500 1080 0 0 {name=l3029 lab=VDD}
C {devices/lab_pin.sym} 6500 1160 0 0 {name=l3030 lab=VSS}
C {devices/lab_pin.sym} 6820 1080 0 0 {name=l3031 lab=VDD}
C {devices/lab_pin.sym} 6820 1160 0 0 {name=l3032 lab=VSS}
C {devices/lab_pin.sym} 7140 1080 0 0 {name=l3033 lab=VDD}
C {devices/lab_pin.sym} 7140 1160 0 0 {name=l3034 lab=VSS}
C {devices/lab_pin.sym} 7460 1080 0 0 {name=l3035 lab=VDD}
C {devices/lab_pin.sym} 7460 1160 0 0 {name=l3036 lab=VSS}
C {devices/lab_pin.sym} 7780 1080 0 0 {name=l3037 lab=VDD}
C {devices/lab_pin.sym} 7780 1160 0 0 {name=l3038 lab=VSS}
C {devices/lab_pin.sym} 8100 1080 0 0 {name=l3039 lab=VDD}
C {devices/lab_pin.sym} 8100 1160 0 0 {name=l3040 lab=VSS}
C {devices/lab_pin.sym} 8420 1080 0 0 {name=l3041 lab=VDD}
C {devices/lab_pin.sym} 8420 1160 0 0 {name=l3042 lab=VSS}
C {devices/lab_pin.sym} 8740 1080 0 0 {name=l3043 lab=VDD}
C {devices/lab_pin.sym} 8740 1160 0 0 {name=l3044 lab=VSS}
C {devices/lab_pin.sym} 9060 1080 0 0 {name=l3045 lab=VDD}
C {devices/lab_pin.sym} 9060 1160 0 0 {name=l3046 lab=VSS}
C {devices/lab_pin.sym} 9380 1080 0 0 {name=l3047 lab=VDD}
C {devices/lab_pin.sym} 9380 1160 0 0 {name=l3048 lab=VSS}
C {devices/lab_pin.sym} 9700 1080 0 0 {name=l3049 lab=VDD}
C {devices/lab_pin.sym} 9700 1160 0 0 {name=l3050 lab=VSS}
C {devices/lab_pin.sym} 10020 1080 0 0 {name=l3051 lab=VDD}
C {devices/lab_pin.sym} 10020 1160 0 0 {name=l3052 lab=VSS}
C {devices/lab_pin.sym} 100 1360 0 0 {name=l3053 lab=VDD}
C {devices/lab_pin.sym} 100 1440 0 0 {name=l3054 lab=VSS}
C {devices/lab_pin.sym} 420 1360 0 0 {name=l3055 lab=VDD}
C {devices/lab_pin.sym} 420 1440 0 0 {name=l3056 lab=VSS}
C {devices/lab_pin.sym} 740 1360 0 0 {name=l3057 lab=VDD}
C {devices/lab_pin.sym} 740 1440 0 0 {name=l3058 lab=VSS}
C {devices/lab_pin.sym} 1060 1360 0 0 {name=l3059 lab=VDD}
C {devices/lab_pin.sym} 1060 1440 0 0 {name=l3060 lab=VSS}
C {devices/lab_pin.sym} 1380 1360 0 0 {name=l3061 lab=VDD}
C {devices/lab_pin.sym} 1380 1440 0 0 {name=l3062 lab=VSS}
C {devices/lab_pin.sym} 1700 1360 0 0 {name=l3063 lab=VDD}
C {devices/lab_pin.sym} 1700 1440 0 0 {name=l3064 lab=VSS}
C {devices/lab_pin.sym} 2020 1360 0 0 {name=l3065 lab=VDD}
C {devices/lab_pin.sym} 2020 1440 0 0 {name=l3066 lab=VSS}
C {devices/lab_pin.sym} 2340 1360 0 0 {name=l3067 lab=VDD}
C {devices/lab_pin.sym} 2340 1440 0 0 {name=l3068 lab=VSS}
C {devices/lab_pin.sym} 2660 1360 0 0 {name=l3069 lab=VDD}
C {devices/lab_pin.sym} 2660 1440 0 0 {name=l3070 lab=VSS}
C {devices/lab_pin.sym} 2980 1360 0 0 {name=l3071 lab=VDD}
C {devices/lab_pin.sym} 2980 1440 0 0 {name=l3072 lab=VSS}
C {devices/lab_pin.sym} 3300 1360 0 0 {name=l3073 lab=VDD}
C {devices/lab_pin.sym} 3300 1440 0 0 {name=l3074 lab=VSS}
C {devices/lab_pin.sym} 3620 1360 0 0 {name=l3075 lab=VDD}
C {devices/lab_pin.sym} 3620 1440 0 0 {name=l3076 lab=VSS}
C {devices/lab_pin.sym} 3940 1360 0 0 {name=l3077 lab=VDD}
C {devices/lab_pin.sym} 3940 1440 0 0 {name=l3078 lab=VSS}
C {devices/lab_pin.sym} 4260 1360 0 0 {name=l3079 lab=VDD}
C {devices/lab_pin.sym} 4260 1440 0 0 {name=l3080 lab=VSS}
C {devices/lab_pin.sym} 4580 1360 0 0 {name=l3081 lab=VDD}
C {devices/lab_pin.sym} 4580 1440 0 0 {name=l3082 lab=VSS}
C {devices/lab_pin.sym} 4900 1360 0 0 {name=l3083 lab=VDD}
C {devices/lab_pin.sym} 4900 1440 0 0 {name=l3084 lab=VSS}
C {devices/lab_pin.sym} 5220 1360 0 0 {name=l3085 lab=VDD}
C {devices/lab_pin.sym} 5220 1440 0 0 {name=l3086 lab=VSS}
C {devices/lab_pin.sym} 5540 1360 0 0 {name=l3087 lab=VDD}
C {devices/lab_pin.sym} 5540 1440 0 0 {name=l3088 lab=VSS}
C {devices/lab_pin.sym} 5860 1360 0 0 {name=l3089 lab=VDD}
C {devices/lab_pin.sym} 5860 1440 0 0 {name=l3090 lab=VSS}
C {devices/lab_pin.sym} 6180 1360 0 0 {name=l3091 lab=VDD}
C {devices/lab_pin.sym} 6180 1440 0 0 {name=l3092 lab=VSS}
C {devices/lab_pin.sym} 6500 1360 0 0 {name=l3093 lab=VDD}
C {devices/lab_pin.sym} 6500 1440 0 0 {name=l3094 lab=VSS}
C {devices/lab_pin.sym} 6820 1360 0 0 {name=l3095 lab=VDD}
C {devices/lab_pin.sym} 6820 1440 0 0 {name=l3096 lab=VSS}
C {devices/lab_pin.sym} 7140 1360 0 0 {name=l3097 lab=VDD}
C {devices/lab_pin.sym} 7140 1440 0 0 {name=l3098 lab=VSS}
C {devices/lab_pin.sym} 7460 1360 0 0 {name=l3099 lab=VDD}
C {devices/lab_pin.sym} 7460 1440 0 0 {name=l3100 lab=VSS}
C {devices/lab_pin.sym} 7780 1360 0 0 {name=l3101 lab=VDD}
C {devices/lab_pin.sym} 7780 1440 0 0 {name=l3102 lab=VSS}
C {devices/lab_pin.sym} 8100 1360 0 0 {name=l3103 lab=VDD}
C {devices/lab_pin.sym} 8100 1440 0 0 {name=l3104 lab=VSS}
C {devices/lab_pin.sym} 8420 1360 0 0 {name=l3105 lab=VDD}
C {devices/lab_pin.sym} 8420 1440 0 0 {name=l3106 lab=VSS}
C {devices/lab_pin.sym} 8740 1360 0 0 {name=l3107 lab=VDD}
C {devices/lab_pin.sym} 8740 1440 0 0 {name=l3108 lab=VSS}
C {devices/lab_pin.sym} 9060 1360 0 0 {name=l3109 lab=VDD}
C {devices/lab_pin.sym} 9060 1440 0 0 {name=l3110 lab=VSS}
C {devices/lab_pin.sym} 9380 1360 0 0 {name=l3111 lab=VDD}
C {devices/lab_pin.sym} 9380 1440 0 0 {name=l3112 lab=VSS}
C {devices/lab_pin.sym} 9700 1360 0 0 {name=l3113 lab=VDD}
C {devices/lab_pin.sym} 9700 1440 0 0 {name=l3114 lab=VSS}
C {devices/lab_pin.sym} 10020 1360 0 0 {name=l3115 lab=VDD}
C {devices/lab_pin.sym} 10020 1440 0 0 {name=l3116 lab=VSS}
C {devices/lab_pin.sym} 100 1640 0 0 {name=l3117 lab=VDD}
C {devices/lab_pin.sym} 100 1720 0 0 {name=l3118 lab=VSS}
C {devices/lab_pin.sym} 420 1640 0 0 {name=l3119 lab=VDD}
C {devices/lab_pin.sym} 420 1720 0 0 {name=l3120 lab=VSS}
C {devices/lab_pin.sym} 740 1640 0 0 {name=l3121 lab=VDD}
C {devices/lab_pin.sym} 740 1720 0 0 {name=l3122 lab=VSS}
C {devices/lab_pin.sym} 1060 1640 0 0 {name=l3123 lab=VDD}
C {devices/lab_pin.sym} 1060 1720 0 0 {name=l3124 lab=VSS}
C {devices/lab_pin.sym} 1380 1640 0 0 {name=l3125 lab=VDD}
C {devices/lab_pin.sym} 1380 1720 0 0 {name=l3126 lab=VSS}
C {devices/lab_pin.sym} 1700 1640 0 0 {name=l3127 lab=VDD}
C {devices/lab_pin.sym} 1700 1720 0 0 {name=l3128 lab=VSS}
C {devices/lab_pin.sym} 2020 1640 0 0 {name=l3129 lab=VDD}
C {devices/lab_pin.sym} 2020 1720 0 0 {name=l3130 lab=VSS}
C {devices/lab_pin.sym} 2340 1640 0 0 {name=l3131 lab=VDD}
C {devices/lab_pin.sym} 2340 1720 0 0 {name=l3132 lab=VSS}
C {devices/lab_pin.sym} 2660 1640 0 0 {name=l3133 lab=VDD}
C {devices/lab_pin.sym} 2660 1720 0 0 {name=l3134 lab=VSS}
C {devices/lab_pin.sym} 2980 1640 0 0 {name=l3135 lab=VDD}
C {devices/lab_pin.sym} 2980 1720 0 0 {name=l3136 lab=VSS}
C {devices/lab_pin.sym} 3300 1640 0 0 {name=l3137 lab=VDD}
C {devices/lab_pin.sym} 3300 1720 0 0 {name=l3138 lab=VSS}
C {devices/lab_pin.sym} 3620 1640 0 0 {name=l3139 lab=VDD}
C {devices/lab_pin.sym} 3620 1720 0 0 {name=l3140 lab=VSS}
C {devices/lab_pin.sym} 3940 1640 0 0 {name=l3141 lab=VDD}
C {devices/lab_pin.sym} 3940 1720 0 0 {name=l3142 lab=VSS}
C {devices/lab_pin.sym} 4260 1640 0 0 {name=l3143 lab=VDD}
C {devices/lab_pin.sym} 4260 1720 0 0 {name=l3144 lab=VSS}
C {devices/lab_pin.sym} 4580 1640 0 0 {name=l3145 lab=VDD}
C {devices/lab_pin.sym} 4580 1720 0 0 {name=l3146 lab=VSS}
C {devices/lab_pin.sym} 4900 1640 0 0 {name=l3147 lab=VDD}
C {devices/lab_pin.sym} 4900 1720 0 0 {name=l3148 lab=VSS}
C {devices/lab_pin.sym} 5220 1640 0 0 {name=l3149 lab=VDD}
C {devices/lab_pin.sym} 5220 1720 0 0 {name=l3150 lab=VSS}
C {devices/lab_pin.sym} 5540 1640 0 0 {name=l3151 lab=VDD}
C {devices/lab_pin.sym} 5540 1720 0 0 {name=l3152 lab=VSS}
C {devices/lab_pin.sym} 5860 1640 0 0 {name=l3153 lab=VDD}
C {devices/lab_pin.sym} 5860 1720 0 0 {name=l3154 lab=VSS}
C {devices/lab_pin.sym} 6180 1640 0 0 {name=l3155 lab=VDD}
C {devices/lab_pin.sym} 6180 1720 0 0 {name=l3156 lab=VSS}
C {devices/lab_pin.sym} 6500 1640 0 0 {name=l3157 lab=VDD}
C {devices/lab_pin.sym} 6500 1720 0 0 {name=l3158 lab=VSS}
C {devices/lab_pin.sym} 6820 1640 0 0 {name=l3159 lab=VDD}
C {devices/lab_pin.sym} 6820 1720 0 0 {name=l3160 lab=VSS}
C {devices/lab_pin.sym} 7140 1640 0 0 {name=l3161 lab=VDD}
C {devices/lab_pin.sym} 7140 1720 0 0 {name=l3162 lab=VSS}
C {devices/lab_pin.sym} 7460 1640 0 0 {name=l3163 lab=VDD}
C {devices/lab_pin.sym} 7460 1720 0 0 {name=l3164 lab=VSS}
C {devices/lab_pin.sym} 7780 1640 0 0 {name=l3165 lab=VDD}
C {devices/lab_pin.sym} 7780 1720 0 0 {name=l3166 lab=VSS}
C {devices/lab_pin.sym} 8100 1640 0 0 {name=l3167 lab=VDD}
C {devices/lab_pin.sym} 8100 1720 0 0 {name=l3168 lab=VSS}
C {devices/lab_pin.sym} 8420 1640 0 0 {name=l3169 lab=VDD}
C {devices/lab_pin.sym} 8420 1720 0 0 {name=l3170 lab=VSS}
C {devices/lab_pin.sym} 8740 1640 0 0 {name=l3171 lab=VDD}
C {devices/lab_pin.sym} 8740 1720 0 0 {name=l3172 lab=VSS}
C {devices/lab_pin.sym} 9060 1640 0 0 {name=l3173 lab=VDD}
C {devices/lab_pin.sym} 9060 1720 0 0 {name=l3174 lab=VSS}
C {devices/lab_pin.sym} 9380 1640 0 0 {name=l3175 lab=VDD}
C {devices/lab_pin.sym} 9380 1720 0 0 {name=l3176 lab=VSS}
C {devices/lab_pin.sym} 9700 1640 0 0 {name=l3177 lab=VDD}
C {devices/lab_pin.sym} 9700 1720 0 0 {name=l3178 lab=VSS}
C {devices/lab_pin.sym} 10020 1640 0 0 {name=l3179 lab=VDD}
C {devices/lab_pin.sym} 10020 1720 0 0 {name=l3180 lab=VSS}
C {devices/lab_pin.sym} 100 1920 0 0 {name=l3181 lab=VDD}
C {devices/lab_pin.sym} 100 2000 0 0 {name=l3182 lab=VSS}
C {devices/lab_pin.sym} 420 1920 0 0 {name=l3183 lab=VDD}
C {devices/lab_pin.sym} 420 2000 0 0 {name=l3184 lab=VSS}
C {devices/lab_pin.sym} 740 1920 0 0 {name=l3185 lab=VDD}
C {devices/lab_pin.sym} 740 2000 0 0 {name=l3186 lab=VSS}
C {devices/lab_pin.sym} 1060 1920 0 0 {name=l3187 lab=VDD}
C {devices/lab_pin.sym} 1060 2000 0 0 {name=l3188 lab=VSS}
C {devices/lab_pin.sym} 1380 1920 0 0 {name=l3189 lab=VDD}
C {devices/lab_pin.sym} 1380 2000 0 0 {name=l3190 lab=VSS}
C {devices/lab_pin.sym} 1700 1920 0 0 {name=l3191 lab=VDD}
C {devices/lab_pin.sym} 1700 2000 0 0 {name=l3192 lab=VSS}
C {devices/lab_pin.sym} 2020 1920 0 0 {name=l3193 lab=VDD}
C {devices/lab_pin.sym} 2020 2000 0 0 {name=l3194 lab=VSS}
C {devices/lab_pin.sym} 2340 1920 0 0 {name=l3195 lab=VDD}
C {devices/lab_pin.sym} 2340 2000 0 0 {name=l3196 lab=VSS}
C {devices/lab_pin.sym} 2660 1920 0 0 {name=l3197 lab=VDD}
C {devices/lab_pin.sym} 2660 2000 0 0 {name=l3198 lab=VSS}
C {devices/lab_pin.sym} 2980 1920 0 0 {name=l3199 lab=VDD}
C {devices/lab_pin.sym} 2980 2000 0 0 {name=l3200 lab=VSS}
C {devices/lab_pin.sym} 3300 1920 0 0 {name=l3201 lab=VDD}
C {devices/lab_pin.sym} 3300 2000 0 0 {name=l3202 lab=VSS}
C {devices/lab_pin.sym} 3620 1920 0 0 {name=l3203 lab=VDD}
C {devices/lab_pin.sym} 3620 2000 0 0 {name=l3204 lab=VSS}
C {devices/lab_pin.sym} 3940 1920 0 0 {name=l3205 lab=VDD}
C {devices/lab_pin.sym} 3940 2000 0 0 {name=l3206 lab=VSS}
C {devices/lab_pin.sym} 4260 1920 0 0 {name=l3207 lab=VDD}
C {devices/lab_pin.sym} 4260 2000 0 0 {name=l3208 lab=VSS}
C {devices/lab_pin.sym} 4580 1920 0 0 {name=l3209 lab=VDD}
C {devices/lab_pin.sym} 4580 2000 0 0 {name=l3210 lab=VSS}
C {devices/lab_pin.sym} 4900 1920 0 0 {name=l3211 lab=VDD}
C {devices/lab_pin.sym} 4900 2000 0 0 {name=l3212 lab=VSS}
C {devices/lab_pin.sym} 5220 1920 0 0 {name=l3213 lab=VDD}
C {devices/lab_pin.sym} 5220 2000 0 0 {name=l3214 lab=VSS}
C {devices/lab_pin.sym} 5540 1920 0 0 {name=l3215 lab=VDD}
C {devices/lab_pin.sym} 5540 2000 0 0 {name=l3216 lab=VSS}
C {devices/lab_pin.sym} 5860 1920 0 0 {name=l3217 lab=VDD}
C {devices/lab_pin.sym} 5860 2000 0 0 {name=l3218 lab=VSS}
C {devices/lab_pin.sym} 6180 1920 0 0 {name=l3219 lab=VDD}
C {devices/lab_pin.sym} 6180 2000 0 0 {name=l3220 lab=VSS}
C {devices/lab_pin.sym} 6500 1920 0 0 {name=l3221 lab=VDD}
C {devices/lab_pin.sym} 6500 2000 0 0 {name=l3222 lab=VSS}
C {devices/lab_pin.sym} 6820 1920 0 0 {name=l3223 lab=VDD}
C {devices/lab_pin.sym} 6820 2000 0 0 {name=l3224 lab=VSS}
C {devices/lab_pin.sym} 7140 1920 0 0 {name=l3225 lab=VDD}
C {devices/lab_pin.sym} 7140 2000 0 0 {name=l3226 lab=VSS}
C {devices/lab_pin.sym} 7460 1920 0 0 {name=l3227 lab=VDD}
C {devices/lab_pin.sym} 7460 2000 0 0 {name=l3228 lab=VSS}
C {devices/lab_pin.sym} 7780 1920 0 0 {name=l3229 lab=VDD}
C {devices/lab_pin.sym} 7780 2000 0 0 {name=l3230 lab=VSS}
C {devices/lab_pin.sym} 8100 1920 0 0 {name=l3231 lab=VDD}
C {devices/lab_pin.sym} 8100 2000 0 0 {name=l3232 lab=VSS}
C {devices/lab_pin.sym} 8420 1920 0 0 {name=l3233 lab=VDD}
C {devices/lab_pin.sym} 8420 2000 0 0 {name=l3234 lab=VSS}
C {devices/lab_pin.sym} 8740 1920 0 0 {name=l3235 lab=VDD}
C {devices/lab_pin.sym} 8740 2000 0 0 {name=l3236 lab=VSS}
C {devices/lab_pin.sym} 9060 1920 0 0 {name=l3237 lab=VDD}
C {devices/lab_pin.sym} 9060 2000 0 0 {name=l3238 lab=VSS}
C {devices/lab_pin.sym} 9380 1920 0 0 {name=l3239 lab=VDD}
C {devices/lab_pin.sym} 9380 2000 0 0 {name=l3240 lab=VSS}
C {devices/lab_pin.sym} 9700 1920 0 0 {name=l3241 lab=VDD}
C {devices/lab_pin.sym} 9700 2000 0 0 {name=l3242 lab=VSS}
C {devices/lab_pin.sym} 10020 1920 0 0 {name=l3243 lab=VDD}
C {devices/lab_pin.sym} 10020 2000 0 0 {name=l3244 lab=VSS}
C {devices/lab_pin.sym} 100 2200 0 0 {name=l3245 lab=VDD}
C {devices/lab_pin.sym} 100 2280 0 0 {name=l3246 lab=VSS}
C {devices/lab_pin.sym} 420 2200 0 0 {name=l3247 lab=VDD}
C {devices/lab_pin.sym} 420 2280 0 0 {name=l3248 lab=VSS}
C {devices/lab_pin.sym} 740 2200 0 0 {name=l3249 lab=VDD}
C {devices/lab_pin.sym} 740 2280 0 0 {name=l3250 lab=VSS}
C {devices/lab_pin.sym} 1060 2200 0 0 {name=l3251 lab=VDD}
C {devices/lab_pin.sym} 1060 2280 0 0 {name=l3252 lab=VSS}
C {devices/lab_pin.sym} 1380 2200 0 0 {name=l3253 lab=VDD}
C {devices/lab_pin.sym} 1380 2280 0 0 {name=l3254 lab=VSS}
C {devices/lab_pin.sym} 1700 2200 0 0 {name=l3255 lab=VDD}
C {devices/lab_pin.sym} 1700 2280 0 0 {name=l3256 lab=VSS}
C {devices/lab_pin.sym} 2020 2200 0 0 {name=l3257 lab=VDD}
C {devices/lab_pin.sym} 2020 2280 0 0 {name=l3258 lab=VSS}
C {devices/lab_pin.sym} 2340 2200 0 0 {name=l3259 lab=VDD}
C {devices/lab_pin.sym} 2340 2280 0 0 {name=l3260 lab=VSS}
C {devices/lab_pin.sym} 2660 2200 0 0 {name=l3261 lab=VDD}
C {devices/lab_pin.sym} 2660 2280 0 0 {name=l3262 lab=VSS}
C {devices/lab_pin.sym} 2980 2200 0 0 {name=l3263 lab=VDD}
C {devices/lab_pin.sym} 2980 2280 0 0 {name=l3264 lab=VSS}
C {devices/lab_pin.sym} 3300 2200 0 0 {name=l3265 lab=VDD}
C {devices/lab_pin.sym} 3300 2280 0 0 {name=l3266 lab=VSS}
C {devices/lab_pin.sym} 3620 2200 0 0 {name=l3267 lab=VDD}
C {devices/lab_pin.sym} 3620 2280 0 0 {name=l3268 lab=VSS}
C {devices/lab_pin.sym} 3940 2200 0 0 {name=l3269 lab=VDD}
C {devices/lab_pin.sym} 3940 2280 0 0 {name=l3270 lab=VSS}
C {devices/lab_pin.sym} 4260 2200 0 0 {name=l3271 lab=VDD}
C {devices/lab_pin.sym} 4260 2280 0 0 {name=l3272 lab=VSS}
C {devices/lab_pin.sym} 4580 2200 0 0 {name=l3273 lab=VDD}
C {devices/lab_pin.sym} 4580 2280 0 0 {name=l3274 lab=VSS}
C {devices/lab_pin.sym} 4900 2200 0 0 {name=l3275 lab=VDD}
C {devices/lab_pin.sym} 4900 2280 0 0 {name=l3276 lab=VSS}
C {devices/lab_pin.sym} 5220 2200 0 0 {name=l3277 lab=VDD}
C {devices/lab_pin.sym} 5220 2280 0 0 {name=l3278 lab=VSS}
C {devices/lab_pin.sym} 5540 2200 0 0 {name=l3279 lab=VDD}
C {devices/lab_pin.sym} 5540 2280 0 0 {name=l3280 lab=VSS}
C {devices/lab_pin.sym} 5860 2200 0 0 {name=l3281 lab=VDD}
C {devices/lab_pin.sym} 5860 2280 0 0 {name=l3282 lab=VSS}
C {devices/lab_pin.sym} 6180 2200 0 0 {name=l3283 lab=VDD}
C {devices/lab_pin.sym} 6180 2280 0 0 {name=l3284 lab=VSS}
C {devices/lab_pin.sym} 6500 2200 0 0 {name=l3285 lab=VDD}
C {devices/lab_pin.sym} 6500 2280 0 0 {name=l3286 lab=VSS}
C {devices/lab_pin.sym} 6820 2200 0 0 {name=l3287 lab=VDD}
C {devices/lab_pin.sym} 6820 2280 0 0 {name=l3288 lab=VSS}
C {devices/lab_pin.sym} 7140 2200 0 0 {name=l3289 lab=VDD}
C {devices/lab_pin.sym} 7140 2280 0 0 {name=l3290 lab=VSS}
C {devices/lab_pin.sym} 7460 2200 0 0 {name=l3291 lab=VDD}
C {devices/lab_pin.sym} 7460 2280 0 0 {name=l3292 lab=VSS}
C {devices/lab_pin.sym} 7780 2200 0 0 {name=l3293 lab=VDD}
C {devices/lab_pin.sym} 7780 2280 0 0 {name=l3294 lab=VSS}
C {devices/lab_pin.sym} 8100 2200 0 0 {name=l3295 lab=VDD}
C {devices/lab_pin.sym} 8100 2280 0 0 {name=l3296 lab=VSS}
C {devices/lab_pin.sym} 8420 2200 0 0 {name=l3297 lab=VDD}
C {devices/lab_pin.sym} 8420 2280 0 0 {name=l3298 lab=VSS}
C {devices/lab_pin.sym} 8740 2200 0 0 {name=l3299 lab=VDD}
C {devices/lab_pin.sym} 8740 2280 0 0 {name=l3300 lab=VSS}
C {devices/lab_pin.sym} 9060 2200 0 0 {name=l3301 lab=VDD}
C {devices/lab_pin.sym} 9060 2280 0 0 {name=l3302 lab=VSS}
C {devices/lab_pin.sym} 9380 2200 0 0 {name=l3303 lab=VDD}
C {devices/lab_pin.sym} 9380 2280 0 0 {name=l3304 lab=VSS}
C {devices/lab_pin.sym} 9700 2200 0 0 {name=l3305 lab=VDD}
C {devices/lab_pin.sym} 9700 2280 0 0 {name=l3306 lab=VSS}
C {devices/lab_pin.sym} 10020 2200 0 0 {name=l3307 lab=VDD}
C {devices/lab_pin.sym} 10020 2280 0 0 {name=l3308 lab=VSS}
C {devices/lab_pin.sym} 100 2480 0 0 {name=l3309 lab=VDD}
C {devices/lab_pin.sym} 100 2560 0 0 {name=l3310 lab=VSS}
C {devices/lab_pin.sym} 420 2480 0 0 {name=l3311 lab=VDD}
C {devices/lab_pin.sym} 420 2560 0 0 {name=l3312 lab=VSS}
C {devices/lab_pin.sym} 740 2480 0 0 {name=l3313 lab=VDD}
C {devices/lab_pin.sym} 740 2560 0 0 {name=l3314 lab=VSS}
C {devices/lab_pin.sym} 1060 2480 0 0 {name=l3315 lab=VDD}
C {devices/lab_pin.sym} 1060 2560 0 0 {name=l3316 lab=VSS}
C {devices/lab_pin.sym} 1380 2480 0 0 {name=l3317 lab=VDD}
C {devices/lab_pin.sym} 1380 2560 0 0 {name=l3318 lab=VSS}
C {devices/lab_pin.sym} 1700 2480 0 0 {name=l3319 lab=VDD}
C {devices/lab_pin.sym} 1700 2560 0 0 {name=l3320 lab=VSS}
C {devices/lab_pin.sym} 2020 2480 0 0 {name=l3321 lab=VDD}
C {devices/lab_pin.sym} 2020 2560 0 0 {name=l3322 lab=VSS}
C {devices/lab_pin.sym} 2340 2480 0 0 {name=l3323 lab=VDD}
C {devices/lab_pin.sym} 2340 2560 0 0 {name=l3324 lab=VSS}
C {devices/lab_pin.sym} 2660 2480 0 0 {name=l3325 lab=VDD}
C {devices/lab_pin.sym} 2660 2560 0 0 {name=l3326 lab=VSS}
C {devices/lab_pin.sym} 2980 2480 0 0 {name=l3327 lab=VDD}
C {devices/lab_pin.sym} 2980 2560 0 0 {name=l3328 lab=VSS}
C {devices/lab_pin.sym} 3300 2480 0 0 {name=l3329 lab=VDD}
C {devices/lab_pin.sym} 3300 2560 0 0 {name=l3330 lab=VSS}
C {devices/lab_pin.sym} 3620 2480 0 0 {name=l3331 lab=VDD}
C {devices/lab_pin.sym} 3620 2560 0 0 {name=l3332 lab=VSS}
C {devices/lab_pin.sym} 3940 2480 0 0 {name=l3333 lab=VDD}
C {devices/lab_pin.sym} 3940 2560 0 0 {name=l3334 lab=VSS}
C {devices/lab_pin.sym} 4260 2480 0 0 {name=l3335 lab=VDD}
C {devices/lab_pin.sym} 4260 2560 0 0 {name=l3336 lab=VSS}
C {devices/lab_pin.sym} 4580 2480 0 0 {name=l3337 lab=VDD}
C {devices/lab_pin.sym} 4580 2560 0 0 {name=l3338 lab=VSS}
C {devices/lab_pin.sym} 4900 2480 0 0 {name=l3339 lab=VDD}
C {devices/lab_pin.sym} 4900 2560 0 0 {name=l3340 lab=VSS}
C {devices/lab_pin.sym} 5220 2480 0 0 {name=l3341 lab=VDD}
C {devices/lab_pin.sym} 5220 2560 0 0 {name=l3342 lab=VSS}
C {devices/lab_pin.sym} 5540 2480 0 0 {name=l3343 lab=VDD}
C {devices/lab_pin.sym} 5540 2560 0 0 {name=l3344 lab=VSS}
C {devices/lab_pin.sym} 5860 2480 0 0 {name=l3345 lab=VDD}
C {devices/lab_pin.sym} 5860 2560 0 0 {name=l3346 lab=VSS}
C {devices/lab_pin.sym} 6180 2480 0 0 {name=l3347 lab=VDD}
C {devices/lab_pin.sym} 6180 2560 0 0 {name=l3348 lab=VSS}
C {devices/lab_pin.sym} 6500 2480 0 0 {name=l3349 lab=VDD}
C {devices/lab_pin.sym} 6500 2560 0 0 {name=l3350 lab=VSS}
C {devices/lab_pin.sym} 6820 2480 0 0 {name=l3351 lab=VDD}
C {devices/lab_pin.sym} 6820 2560 0 0 {name=l3352 lab=VSS}
C {devices/lab_pin.sym} 7140 2480 0 0 {name=l3353 lab=VDD}
C {devices/lab_pin.sym} 7140 2560 0 0 {name=l3354 lab=VSS}
C {devices/lab_pin.sym} 7460 2480 0 0 {name=l3355 lab=VDD}
C {devices/lab_pin.sym} 7460 2560 0 0 {name=l3356 lab=VSS}
C {devices/lab_pin.sym} 7780 2480 0 0 {name=l3357 lab=VDD}
C {devices/lab_pin.sym} 7780 2560 0 0 {name=l3358 lab=VSS}
C {devices/lab_pin.sym} 8100 2480 0 0 {name=l3359 lab=VDD}
C {devices/lab_pin.sym} 8100 2560 0 0 {name=l3360 lab=VSS}
C {devices/lab_pin.sym} 8420 2480 0 0 {name=l3361 lab=VDD}
C {devices/lab_pin.sym} 8420 2560 0 0 {name=l3362 lab=VSS}
C {devices/lab_pin.sym} 8740 2480 0 0 {name=l3363 lab=VDD}
C {devices/lab_pin.sym} 8740 2560 0 0 {name=l3364 lab=VSS}
C {devices/lab_pin.sym} 9060 2480 0 0 {name=l3365 lab=VDD}
C {devices/lab_pin.sym} 9060 2560 0 0 {name=l3366 lab=VSS}
C {devices/lab_pin.sym} 9380 2480 0 0 {name=l3367 lab=VDD}
C {devices/lab_pin.sym} 9380 2560 0 0 {name=l3368 lab=VSS}
C {devices/lab_pin.sym} 9700 2480 0 0 {name=l3369 lab=VDD}
C {devices/lab_pin.sym} 9700 2560 0 0 {name=l3370 lab=VSS}
C {devices/lab_pin.sym} 10020 2480 0 0 {name=l3371 lab=VDD}
C {devices/lab_pin.sym} 10020 2560 0 0 {name=l3372 lab=VSS}
C {devices/lab_pin.sym} 100 2760 0 0 {name=l3373 lab=VDD}
C {devices/lab_pin.sym} 100 2840 0 0 {name=l3374 lab=VSS}
C {devices/lab_pin.sym} 420 2760 0 0 {name=l3375 lab=VDD}
C {devices/lab_pin.sym} 420 2840 0 0 {name=l3376 lab=VSS}
C {devices/lab_pin.sym} 740 2760 0 0 {name=l3377 lab=VDD}
C {devices/lab_pin.sym} 740 2840 0 0 {name=l3378 lab=VSS}
C {devices/lab_pin.sym} 1060 2760 0 0 {name=l3379 lab=VDD}
C {devices/lab_pin.sym} 1060 2840 0 0 {name=l3380 lab=VSS}
C {devices/lab_pin.sym} 1380 2760 0 0 {name=l3381 lab=VDD}
C {devices/lab_pin.sym} 1380 2840 0 0 {name=l3382 lab=VSS}
C {devices/lab_pin.sym} 1700 2760 0 0 {name=l3383 lab=VDD}
C {devices/lab_pin.sym} 1700 2840 0 0 {name=l3384 lab=VSS}
C {devices/lab_pin.sym} 2020 2760 0 0 {name=l3385 lab=VDD}
C {devices/lab_pin.sym} 2020 2840 0 0 {name=l3386 lab=VSS}
C {devices/lab_pin.sym} 2340 2760 0 0 {name=l3387 lab=VDD}
C {devices/lab_pin.sym} 2340 2840 0 0 {name=l3388 lab=VSS}
C {devices/lab_pin.sym} 2660 2760 0 0 {name=l3389 lab=VDD}
C {devices/lab_pin.sym} 2660 2840 0 0 {name=l3390 lab=VSS}
C {devices/lab_pin.sym} 2980 2760 0 0 {name=l3391 lab=VDD}
C {devices/lab_pin.sym} 2980 2840 0 0 {name=l3392 lab=VSS}
C {devices/lab_pin.sym} 3300 2760 0 0 {name=l3393 lab=VDD}
C {devices/lab_pin.sym} 3300 2840 0 0 {name=l3394 lab=VSS}
C {devices/lab_pin.sym} 3620 2760 0 0 {name=l3395 lab=VDD}
C {devices/lab_pin.sym} 3620 2840 0 0 {name=l3396 lab=VSS}
C {devices/lab_pin.sym} 3940 2760 0 0 {name=l3397 lab=VDD}
C {devices/lab_pin.sym} 3940 2840 0 0 {name=l3398 lab=VSS}
C {devices/lab_pin.sym} 4260 2760 0 0 {name=l3399 lab=VDD}
C {devices/lab_pin.sym} 4260 2840 0 0 {name=l3400 lab=VSS}
C {devices/lab_pin.sym} 4580 2760 0 0 {name=l3401 lab=VDD}
C {devices/lab_pin.sym} 4580 2840 0 0 {name=l3402 lab=VSS}
C {devices/lab_pin.sym} 4900 2760 0 0 {name=l3403 lab=VDD}
C {devices/lab_pin.sym} 4900 2840 0 0 {name=l3404 lab=VSS}
C {devices/lab_pin.sym} 5220 2760 0 0 {name=l3405 lab=VDD}
C {devices/lab_pin.sym} 5220 2840 0 0 {name=l3406 lab=VSS}
C {devices/lab_pin.sym} 5540 2760 0 0 {name=l3407 lab=VDD}
C {devices/lab_pin.sym} 5540 2840 0 0 {name=l3408 lab=VSS}
C {devices/lab_pin.sym} 5860 2760 0 0 {name=l3409 lab=VDD}
C {devices/lab_pin.sym} 5860 2840 0 0 {name=l3410 lab=VSS}
C {devices/lab_pin.sym} 6180 2760 0 0 {name=l3411 lab=VDD}
C {devices/lab_pin.sym} 6180 2840 0 0 {name=l3412 lab=VSS}
C {devices/lab_pin.sym} 6500 2760 0 0 {name=l3413 lab=VDD}
C {devices/lab_pin.sym} 6500 2840 0 0 {name=l3414 lab=VSS}
C {devices/lab_pin.sym} 6820 2760 0 0 {name=l3415 lab=VDD}
C {devices/lab_pin.sym} 6820 2840 0 0 {name=l3416 lab=VSS}
C {devices/lab_pin.sym} 7140 2760 0 0 {name=l3417 lab=VDD}
C {devices/lab_pin.sym} 7140 2840 0 0 {name=l3418 lab=VSS}
C {devices/lab_pin.sym} 7460 2760 0 0 {name=l3419 lab=VDD}
C {devices/lab_pin.sym} 7460 2840 0 0 {name=l3420 lab=VSS}
C {devices/lab_pin.sym} 7780 2760 0 0 {name=l3421 lab=VDD}
C {devices/lab_pin.sym} 7780 2840 0 0 {name=l3422 lab=VSS}
C {devices/lab_pin.sym} 8100 2760 0 0 {name=l3423 lab=VDD}
C {devices/lab_pin.sym} 8100 2840 0 0 {name=l3424 lab=VSS}
C {devices/lab_pin.sym} 8420 2760 0 0 {name=l3425 lab=VDD}
C {devices/lab_pin.sym} 8420 2840 0 0 {name=l3426 lab=VSS}
C {devices/lab_pin.sym} 8740 2760 0 0 {name=l3427 lab=VDD}
C {devices/lab_pin.sym} 8740 2840 0 0 {name=l3428 lab=VSS}
C {devices/lab_pin.sym} 9060 2760 0 0 {name=l3429 lab=VDD}
C {devices/lab_pin.sym} 9060 2840 0 0 {name=l3430 lab=VSS}
C {devices/lab_pin.sym} 9380 2760 0 0 {name=l3431 lab=VDD}
C {devices/lab_pin.sym} 9380 2840 0 0 {name=l3432 lab=VSS}
C {devices/lab_pin.sym} 9700 2760 0 0 {name=l3433 lab=VDD}
C {devices/lab_pin.sym} 9700 2840 0 0 {name=l3434 lab=VSS}
C {devices/lab_pin.sym} 10020 2760 0 0 {name=l3435 lab=VDD}
C {devices/lab_pin.sym} 10020 2840 0 0 {name=l3436 lab=VSS}
C {devices/lab_pin.sym} 100 3040 0 0 {name=l3437 lab=VDD}
C {devices/lab_pin.sym} 100 3120 0 0 {name=l3438 lab=VSS}
C {devices/lab_pin.sym} 420 3040 0 0 {name=l3439 lab=VDD}
C {devices/lab_pin.sym} 420 3120 0 0 {name=l3440 lab=VSS}
C {devices/lab_pin.sym} 740 3040 0 0 {name=l3441 lab=VDD}
C {devices/lab_pin.sym} 740 3120 0 0 {name=l3442 lab=VSS}
C {devices/lab_pin.sym} 1060 3040 0 0 {name=l3443 lab=VDD}
C {devices/lab_pin.sym} 1060 3120 0 0 {name=l3444 lab=VSS}
C {devices/lab_pin.sym} 1380 3040 0 0 {name=l3445 lab=VDD}
C {devices/lab_pin.sym} 1380 3120 0 0 {name=l3446 lab=VSS}
C {devices/lab_pin.sym} 1700 3040 0 0 {name=l3447 lab=VDD}
C {devices/lab_pin.sym} 1700 3120 0 0 {name=l3448 lab=VSS}
C {devices/lab_pin.sym} 2020 3040 0 0 {name=l3449 lab=VDD}
C {devices/lab_pin.sym} 2020 3120 0 0 {name=l3450 lab=VSS}
C {devices/lab_pin.sym} 2340 3040 0 0 {name=l3451 lab=VDD}
C {devices/lab_pin.sym} 2340 3120 0 0 {name=l3452 lab=VSS}
C {devices/lab_pin.sym} 2660 3040 0 0 {name=l3453 lab=VDD}
C {devices/lab_pin.sym} 2660 3120 0 0 {name=l3454 lab=VSS}
C {devices/lab_pin.sym} 2980 3040 0 0 {name=l3455 lab=VDD}
C {devices/lab_pin.sym} 2980 3120 0 0 {name=l3456 lab=VSS}
C {devices/lab_pin.sym} 3300 3040 0 0 {name=l3457 lab=VDD}
C {devices/lab_pin.sym} 3300 3120 0 0 {name=l3458 lab=VSS}
C {devices/lab_pin.sym} 3620 3040 0 0 {name=l3459 lab=VDD}
C {devices/lab_pin.sym} 3620 3120 0 0 {name=l3460 lab=VSS}
C {devices/lab_pin.sym} 3940 3040 0 0 {name=l3461 lab=VDD}
C {devices/lab_pin.sym} 3940 3120 0 0 {name=l3462 lab=VSS}
C {devices/lab_pin.sym} 4260 3040 0 0 {name=l3463 lab=VDD}
C {devices/lab_pin.sym} 4260 3120 0 0 {name=l3464 lab=VSS}
C {devices/lab_pin.sym} 4580 3040 0 0 {name=l3465 lab=VDD}
C {devices/lab_pin.sym} 4580 3120 0 0 {name=l3466 lab=VSS}
C {devices/lab_pin.sym} 4900 3040 0 0 {name=l3467 lab=VDD}
C {devices/lab_pin.sym} 4900 3120 0 0 {name=l3468 lab=VSS}
C {devices/lab_pin.sym} 5220 3040 0 0 {name=l3469 lab=VDD}
C {devices/lab_pin.sym} 5220 3120 0 0 {name=l3470 lab=VSS}
C {devices/lab_pin.sym} 5540 3040 0 0 {name=l3471 lab=VDD}
C {devices/lab_pin.sym} 5540 3120 0 0 {name=l3472 lab=VSS}
C {devices/lab_pin.sym} 5860 3040 0 0 {name=l3473 lab=VDD}
C {devices/lab_pin.sym} 5860 3120 0 0 {name=l3474 lab=VSS}
C {devices/lab_pin.sym} 6180 3040 0 0 {name=l3475 lab=VDD}
C {devices/lab_pin.sym} 6180 3120 0 0 {name=l3476 lab=VSS}
C {devices/lab_pin.sym} 6500 3040 0 0 {name=l3477 lab=VDD}
C {devices/lab_pin.sym} 6500 3120 0 0 {name=l3478 lab=VSS}
C {devices/lab_pin.sym} 6820 3040 0 0 {name=l3479 lab=VDD}
C {devices/lab_pin.sym} 6820 3120 0 0 {name=l3480 lab=VSS}
C {devices/lab_pin.sym} 7140 3040 0 0 {name=l3481 lab=VDD}
C {devices/lab_pin.sym} 7140 3120 0 0 {name=l3482 lab=VSS}
C {devices/lab_pin.sym} 7460 3040 0 0 {name=l3483 lab=VDD}
C {devices/lab_pin.sym} 7460 3120 0 0 {name=l3484 lab=VSS}
C {devices/lab_pin.sym} 7780 3040 0 0 {name=l3485 lab=VDD}
C {devices/lab_pin.sym} 7780 3120 0 0 {name=l3486 lab=VSS}
C {devices/lab_pin.sym} 8100 3040 0 0 {name=l3487 lab=VDD}
C {devices/lab_pin.sym} 8100 3120 0 0 {name=l3488 lab=VSS}
C {devices/lab_pin.sym} 8420 3040 0 0 {name=l3489 lab=VDD}
C {devices/lab_pin.sym} 8420 3120 0 0 {name=l3490 lab=VSS}
C {devices/lab_pin.sym} 8740 3040 0 0 {name=l3491 lab=VDD}
C {devices/lab_pin.sym} 8740 3120 0 0 {name=l3492 lab=VSS}
C {devices/lab_pin.sym} 9060 3040 0 0 {name=l3493 lab=VDD}
C {devices/lab_pin.sym} 9060 3120 0 0 {name=l3494 lab=VSS}
C {devices/lab_pin.sym} 9380 3040 0 0 {name=l3495 lab=VDD}
C {devices/lab_pin.sym} 9380 3120 0 0 {name=l3496 lab=VSS}
C {devices/lab_pin.sym} 9700 3040 0 0 {name=l3497 lab=VDD}
C {devices/lab_pin.sym} 9700 3120 0 0 {name=l3498 lab=VSS}
C {devices/lab_pin.sym} 10020 3040 0 0 {name=l3499 lab=VDD}
C {devices/lab_pin.sym} 10020 3120 0 0 {name=l3500 lab=VSS}
C {devices/lab_pin.sym} 100 3320 0 0 {name=l3501 lab=VDD}
C {devices/lab_pin.sym} 100 3400 0 0 {name=l3502 lab=VSS}
C {devices/lab_pin.sym} 420 3320 0 0 {name=l3503 lab=VDD}
C {devices/lab_pin.sym} 420 3400 0 0 {name=l3504 lab=VSS}
C {devices/lab_pin.sym} 740 3320 0 0 {name=l3505 lab=VDD}
C {devices/lab_pin.sym} 740 3400 0 0 {name=l3506 lab=VSS}
C {devices/lab_pin.sym} 1060 3320 0 0 {name=l3507 lab=VDD}
C {devices/lab_pin.sym} 1060 3400 0 0 {name=l3508 lab=VSS}
C {devices/lab_pin.sym} 1380 3320 0 0 {name=l3509 lab=VDD}
C {devices/lab_pin.sym} 1380 3400 0 0 {name=l3510 lab=VSS}
C {devices/lab_pin.sym} 1700 3320 0 0 {name=l3511 lab=VDD}
C {devices/lab_pin.sym} 1700 3400 0 0 {name=l3512 lab=VSS}
C {devices/lab_pin.sym} 2020 3320 0 0 {name=l3513 lab=VDD}
C {devices/lab_pin.sym} 2020 3400 0 0 {name=l3514 lab=VSS}
C {devices/lab_pin.sym} 2340 3320 0 0 {name=l3515 lab=VDD}
C {devices/lab_pin.sym} 2340 3400 0 0 {name=l3516 lab=VSS}
C {devices/lab_pin.sym} 2660 3320 0 0 {name=l3517 lab=VDD}
C {devices/lab_pin.sym} 2660 3400 0 0 {name=l3518 lab=VSS}
C {devices/lab_pin.sym} 2980 3320 0 0 {name=l3519 lab=VDD}
C {devices/lab_pin.sym} 2980 3400 0 0 {name=l3520 lab=VSS}
C {devices/lab_pin.sym} 3300 3320 0 0 {name=l3521 lab=VDD}
C {devices/lab_pin.sym} 3300 3400 0 0 {name=l3522 lab=VSS}
C {devices/lab_pin.sym} 3620 3320 0 0 {name=l3523 lab=VDD}
C {devices/lab_pin.sym} 3620 3400 0 0 {name=l3524 lab=VSS}
C {devices/lab_pin.sym} 3940 3320 0 0 {name=l3525 lab=VDD}
C {devices/lab_pin.sym} 3940 3400 0 0 {name=l3526 lab=VSS}
C {devices/lab_pin.sym} 4260 3320 0 0 {name=l3527 lab=VDD}
C {devices/lab_pin.sym} 4260 3400 0 0 {name=l3528 lab=VSS}
C {devices/lab_pin.sym} 4580 3320 0 0 {name=l3529 lab=VDD}
C {devices/lab_pin.sym} 4580 3400 0 0 {name=l3530 lab=VSS}
C {devices/lab_pin.sym} 4900 3320 0 0 {name=l3531 lab=VDD}
C {devices/lab_pin.sym} 4900 3400 0 0 {name=l3532 lab=VSS}
C {devices/lab_pin.sym} 5220 3320 0 0 {name=l3533 lab=VDD}
C {devices/lab_pin.sym} 5220 3400 0 0 {name=l3534 lab=VSS}
C {devices/lab_pin.sym} 5540 3320 0 0 {name=l3535 lab=VDD}
C {devices/lab_pin.sym} 5540 3400 0 0 {name=l3536 lab=VSS}
C {devices/lab_pin.sym} 5860 3320 0 0 {name=l3537 lab=VDD}
C {devices/lab_pin.sym} 5860 3400 0 0 {name=l3538 lab=VSS}
C {devices/lab_pin.sym} 6180 3320 0 0 {name=l3539 lab=VDD}
C {devices/lab_pin.sym} 6180 3400 0 0 {name=l3540 lab=VSS}
C {devices/lab_pin.sym} 6500 3320 0 0 {name=l3541 lab=VDD}
C {devices/lab_pin.sym} 6500 3400 0 0 {name=l3542 lab=VSS}
C {devices/lab_pin.sym} 6820 3320 0 0 {name=l3543 lab=VDD}
C {devices/lab_pin.sym} 6820 3400 0 0 {name=l3544 lab=VSS}
C {devices/lab_pin.sym} 7140 3320 0 0 {name=l3545 lab=VDD}
C {devices/lab_pin.sym} 7140 3400 0 0 {name=l3546 lab=VSS}
C {devices/lab_pin.sym} 7460 3320 0 0 {name=l3547 lab=VDD}
C {devices/lab_pin.sym} 7460 3400 0 0 {name=l3548 lab=VSS}
C {devices/lab_pin.sym} 7780 3320 0 0 {name=l3549 lab=VDD}
C {devices/lab_pin.sym} 7780 3400 0 0 {name=l3550 lab=VSS}
C {devices/lab_pin.sym} 8100 3320 0 0 {name=l3551 lab=VDD}
C {devices/lab_pin.sym} 8100 3400 0 0 {name=l3552 lab=VSS}
C {devices/lab_pin.sym} 8420 3320 0 0 {name=l3553 lab=VDD}
C {devices/lab_pin.sym} 8420 3400 0 0 {name=l3554 lab=VSS}
C {devices/lab_pin.sym} 8740 3320 0 0 {name=l3555 lab=VDD}
C {devices/lab_pin.sym} 8740 3400 0 0 {name=l3556 lab=VSS}
C {devices/lab_pin.sym} 9060 3320 0 0 {name=l3557 lab=VDD}
C {devices/lab_pin.sym} 9060 3400 0 0 {name=l3558 lab=VSS}
C {devices/lab_pin.sym} 9380 3320 0 0 {name=l3559 lab=VDD}
C {devices/lab_pin.sym} 9380 3400 0 0 {name=l3560 lab=VSS}
C {devices/lab_pin.sym} 9700 3320 0 0 {name=l3561 lab=VDD}
C {devices/lab_pin.sym} 9700 3400 0 0 {name=l3562 lab=VSS}
C {devices/lab_pin.sym} 10020 3320 0 0 {name=l3563 lab=VDD}
C {devices/lab_pin.sym} 10020 3400 0 0 {name=l3564 lab=VSS}
C {devices/lab_pin.sym} 100 3600 0 0 {name=l3565 lab=VDD}
C {devices/lab_pin.sym} 100 3680 0 0 {name=l3566 lab=VSS}
C {devices/lab_pin.sym} 420 3600 0 0 {name=l3567 lab=VDD}
C {devices/lab_pin.sym} 420 3680 0 0 {name=l3568 lab=VSS}
C {devices/lab_pin.sym} 740 3600 0 0 {name=l3569 lab=VDD}
C {devices/lab_pin.sym} 740 3680 0 0 {name=l3570 lab=VSS}
C {devices/lab_pin.sym} 1060 3600 0 0 {name=l3571 lab=VDD}
C {devices/lab_pin.sym} 1060 3680 0 0 {name=l3572 lab=VSS}
C {devices/lab_pin.sym} 1380 3600 0 0 {name=l3573 lab=VDD}
C {devices/lab_pin.sym} 1380 3680 0 0 {name=l3574 lab=VSS}
C {devices/lab_pin.sym} 1700 3600 0 0 {name=l3575 lab=VDD}
C {devices/lab_pin.sym} 1700 3680 0 0 {name=l3576 lab=VSS}
C {devices/lab_pin.sym} 2020 3600 0 0 {name=l3577 lab=VDD}
C {devices/lab_pin.sym} 2020 3680 0 0 {name=l3578 lab=VSS}
C {devices/lab_pin.sym} 2340 3600 0 0 {name=l3579 lab=VDD}
C {devices/lab_pin.sym} 2340 3680 0 0 {name=l3580 lab=VSS}
C {devices/lab_pin.sym} 2660 3600 0 0 {name=l3581 lab=VDD}
C {devices/lab_pin.sym} 2660 3680 0 0 {name=l3582 lab=VSS}
C {devices/lab_pin.sym} 2980 3600 0 0 {name=l3583 lab=VDD}
C {devices/lab_pin.sym} 2980 3680 0 0 {name=l3584 lab=VSS}
C {devices/lab_pin.sym} 3300 3600 0 0 {name=l3585 lab=VDD}
C {devices/lab_pin.sym} 3300 3680 0 0 {name=l3586 lab=VSS}
C {devices/lab_pin.sym} 3620 3600 0 0 {name=l3587 lab=VDD}
C {devices/lab_pin.sym} 3620 3680 0 0 {name=l3588 lab=VSS}
C {devices/lab_pin.sym} 3940 3600 0 0 {name=l3589 lab=VDD}
C {devices/lab_pin.sym} 3940 3680 0 0 {name=l3590 lab=VSS}
C {devices/lab_pin.sym} 4260 3600 0 0 {name=l3591 lab=VDD}
C {devices/lab_pin.sym} 4260 3680 0 0 {name=l3592 lab=VSS}
C {devices/lab_pin.sym} 4580 3600 0 0 {name=l3593 lab=VDD}
C {devices/lab_pin.sym} 4580 3680 0 0 {name=l3594 lab=VSS}
C {devices/lab_pin.sym} 4900 3600 0 0 {name=l3595 lab=VDD}
C {devices/lab_pin.sym} 4900 3680 0 0 {name=l3596 lab=VSS}
C {devices/lab_pin.sym} 5220 3600 0 0 {name=l3597 lab=VDD}
C {devices/lab_pin.sym} 5220 3680 0 0 {name=l3598 lab=VSS}
C {devices/lab_pin.sym} 5540 3600 0 0 {name=l3599 lab=VDD}
C {devices/lab_pin.sym} 5540 3680 0 0 {name=l3600 lab=VSS}
C {devices/lab_pin.sym} 5860 3600 0 0 {name=l3601 lab=VDD}
C {devices/lab_pin.sym} 5860 3680 0 0 {name=l3602 lab=VSS}
C {devices/lab_pin.sym} 6180 3600 0 0 {name=l3603 lab=VDD}
C {devices/lab_pin.sym} 6180 3680 0 0 {name=l3604 lab=VSS}
C {devices/lab_pin.sym} 6500 3600 0 0 {name=l3605 lab=VDD}
C {devices/lab_pin.sym} 6500 3680 0 0 {name=l3606 lab=VSS}
C {devices/lab_pin.sym} 6820 3600 0 0 {name=l3607 lab=VDD}
C {devices/lab_pin.sym} 6820 3680 0 0 {name=l3608 lab=VSS}
C {devices/lab_pin.sym} 7140 3600 0 0 {name=l3609 lab=VDD}
C {devices/lab_pin.sym} 7140 3680 0 0 {name=l3610 lab=VSS}
C {devices/lab_pin.sym} 7460 3600 0 0 {name=l3611 lab=VDD}
C {devices/lab_pin.sym} 7460 3680 0 0 {name=l3612 lab=VSS}
C {devices/lab_pin.sym} 7780 3600 0 0 {name=l3613 lab=VDD}
C {devices/lab_pin.sym} 7780 3680 0 0 {name=l3614 lab=VSS}
C {devices/lab_pin.sym} 8100 3600 0 0 {name=l3615 lab=VDD}
C {devices/lab_pin.sym} 8100 3680 0 0 {name=l3616 lab=VSS}
C {devices/lab_pin.sym} 8420 3600 0 0 {name=l3617 lab=VDD}
C {devices/lab_pin.sym} 8420 3680 0 0 {name=l3618 lab=VSS}
C {devices/lab_pin.sym} 8740 3600 0 0 {name=l3619 lab=VDD}
C {devices/lab_pin.sym} 8740 3680 0 0 {name=l3620 lab=VSS}
C {devices/lab_pin.sym} 9060 3600 0 0 {name=l3621 lab=VDD}
C {devices/lab_pin.sym} 9060 3680 0 0 {name=l3622 lab=VSS}
C {devices/lab_pin.sym} 9380 3600 0 0 {name=l3623 lab=VDD}
C {devices/lab_pin.sym} 9380 3680 0 0 {name=l3624 lab=VSS}
C {devices/lab_pin.sym} 9700 3600 0 0 {name=l3625 lab=VDD}
C {devices/lab_pin.sym} 9700 3680 0 0 {name=l3626 lab=VSS}
C {devices/lab_pin.sym} 10020 3600 0 0 {name=l3627 lab=VDD}
C {devices/lab_pin.sym} 10020 3680 0 0 {name=l3628 lab=VSS}
C {devices/lab_pin.sym} 100 3880 0 0 {name=l3629 lab=VDD}
C {devices/lab_pin.sym} 100 3960 0 0 {name=l3630 lab=VSS}
C {devices/lab_pin.sym} 420 3880 0 0 {name=l3631 lab=VDD}
C {devices/lab_pin.sym} 420 3960 0 0 {name=l3632 lab=VSS}
C {devices/lab_pin.sym} 740 3880 0 0 {name=l3633 lab=VDD}
C {devices/lab_pin.sym} 740 3960 0 0 {name=l3634 lab=VSS}
C {devices/lab_pin.sym} 1060 3880 0 0 {name=l3635 lab=VDD}
C {devices/lab_pin.sym} 1060 3960 0 0 {name=l3636 lab=VSS}
C {devices/lab_pin.sym} 1380 3880 0 0 {name=l3637 lab=VDD}
C {devices/lab_pin.sym} 1380 3960 0 0 {name=l3638 lab=VSS}
C {devices/lab_pin.sym} 1700 3880 0 0 {name=l3639 lab=VDD}
C {devices/lab_pin.sym} 1700 3960 0 0 {name=l3640 lab=VSS}
C {devices/lab_pin.sym} 2020 3880 0 0 {name=l3641 lab=VDD}
C {devices/lab_pin.sym} 2020 3960 0 0 {name=l3642 lab=VSS}
C {devices/lab_pin.sym} 2340 3880 0 0 {name=l3643 lab=VDD}
C {devices/lab_pin.sym} 2340 3960 0 0 {name=l3644 lab=VSS}
C {devices/lab_pin.sym} 2660 3880 0 0 {name=l3645 lab=VDD}
C {devices/lab_pin.sym} 2660 3960 0 0 {name=l3646 lab=VSS}
C {devices/lab_pin.sym} 2980 3880 0 0 {name=l3647 lab=VDD}
C {devices/lab_pin.sym} 2980 3960 0 0 {name=l3648 lab=VSS}
C {devices/lab_pin.sym} 3300 3880 0 0 {name=l3649 lab=VDD}
C {devices/lab_pin.sym} 3300 3960 0 0 {name=l3650 lab=VSS}
C {devices/lab_pin.sym} 3620 3880 0 0 {name=l3651 lab=VDD}
C {devices/lab_pin.sym} 3620 3960 0 0 {name=l3652 lab=VSS}
C {devices/lab_pin.sym} 3940 3880 0 0 {name=l3653 lab=VDD}
C {devices/lab_pin.sym} 3940 3960 0 0 {name=l3654 lab=VSS}
C {devices/lab_pin.sym} 4260 3880 0 0 {name=l3655 lab=VDD}
C {devices/lab_pin.sym} 4260 3960 0 0 {name=l3656 lab=VSS}
C {devices/lab_pin.sym} 4580 3880 0 0 {name=l3657 lab=VDD}
C {devices/lab_pin.sym} 4580 3960 0 0 {name=l3658 lab=VSS}
C {devices/lab_pin.sym} 4900 3880 0 0 {name=l3659 lab=VDD}
C {devices/lab_pin.sym} 4900 3960 0 0 {name=l3660 lab=VSS}
C {devices/lab_pin.sym} 5220 3880 0 0 {name=l3661 lab=VDD}
C {devices/lab_pin.sym} 5220 3960 0 0 {name=l3662 lab=VSS}
C {devices/lab_pin.sym} 5540 3880 0 0 {name=l3663 lab=VDD}
C {devices/lab_pin.sym} 5540 3960 0 0 {name=l3664 lab=VSS}
C {devices/lab_pin.sym} 5860 3880 0 0 {name=l3665 lab=VDD}
C {devices/lab_pin.sym} 5860 3960 0 0 {name=l3666 lab=VSS}
C {devices/lab_pin.sym} 6180 3880 0 0 {name=l3667 lab=VDD}
C {devices/lab_pin.sym} 6180 3960 0 0 {name=l3668 lab=VSS}
C {devices/lab_pin.sym} 6500 3880 0 0 {name=l3669 lab=VDD}
C {devices/lab_pin.sym} 6500 3960 0 0 {name=l3670 lab=VSS}
C {devices/lab_pin.sym} 6820 3880 0 0 {name=l3671 lab=VDD}
C {devices/lab_pin.sym} 6820 3960 0 0 {name=l3672 lab=VSS}
C {devices/lab_pin.sym} 7140 3880 0 0 {name=l3673 lab=VDD}
C {devices/lab_pin.sym} 7140 3960 0 0 {name=l3674 lab=VSS}
C {devices/lab_pin.sym} 7460 3880 0 0 {name=l3675 lab=VDD}
C {devices/lab_pin.sym} 7460 3960 0 0 {name=l3676 lab=VSS}
C {devices/lab_pin.sym} 7780 3880 0 0 {name=l3677 lab=VDD}
C {devices/lab_pin.sym} 7780 3960 0 0 {name=l3678 lab=VSS}
C {devices/lab_pin.sym} 8100 3880 0 0 {name=l3679 lab=VDD}
C {devices/lab_pin.sym} 8100 3960 0 0 {name=l3680 lab=VSS}
C {devices/lab_pin.sym} 8420 3880 0 0 {name=l3681 lab=VDD}
C {devices/lab_pin.sym} 8420 3960 0 0 {name=l3682 lab=VSS}
C {devices/lab_pin.sym} 8740 3880 0 0 {name=l3683 lab=VDD}
C {devices/lab_pin.sym} 8740 3960 0 0 {name=l3684 lab=VSS}
C {devices/lab_pin.sym} 9060 3880 0 0 {name=l3685 lab=VDD}
C {devices/lab_pin.sym} 9060 3960 0 0 {name=l3686 lab=VSS}
C {devices/lab_pin.sym} 9380 3880 0 0 {name=l3687 lab=VDD}
C {devices/lab_pin.sym} 9380 3960 0 0 {name=l3688 lab=VSS}
C {devices/lab_pin.sym} 9700 3880 0 0 {name=l3689 lab=VDD}
C {devices/lab_pin.sym} 9700 3960 0 0 {name=l3690 lab=VSS}
C {devices/lab_pin.sym} 10020 3880 0 0 {name=l3691 lab=VDD}
C {devices/lab_pin.sym} 10020 3960 0 0 {name=l3692 lab=VSS}
C {devices/lab_pin.sym} 100 4160 0 0 {name=l3693 lab=VDD}
C {devices/lab_pin.sym} 100 4240 0 0 {name=l3694 lab=VSS}
C {devices/lab_pin.sym} 420 4160 0 0 {name=l3695 lab=VDD}
C {devices/lab_pin.sym} 420 4240 0 0 {name=l3696 lab=VSS}
C {devices/lab_pin.sym} 740 4160 0 0 {name=l3697 lab=VDD}
C {devices/lab_pin.sym} 740 4240 0 0 {name=l3698 lab=VSS}
C {devices/lab_pin.sym} 1060 4160 0 0 {name=l3699 lab=VDD}
C {devices/lab_pin.sym} 1060 4240 0 0 {name=l3700 lab=VSS}
C {devices/lab_pin.sym} 1380 4160 0 0 {name=l3701 lab=VDD}
C {devices/lab_pin.sym} 1380 4240 0 0 {name=l3702 lab=VSS}
C {devices/lab_pin.sym} 1700 4160 0 0 {name=l3703 lab=VDD}
C {devices/lab_pin.sym} 1700 4240 0 0 {name=l3704 lab=VSS}
C {devices/lab_pin.sym} 2020 4160 0 0 {name=l3705 lab=VDD}
C {devices/lab_pin.sym} 2020 4240 0 0 {name=l3706 lab=VSS}
C {devices/lab_pin.sym} 2340 4160 0 0 {name=l3707 lab=VDD}
C {devices/lab_pin.sym} 2340 4240 0 0 {name=l3708 lab=VSS}
C {devices/lab_pin.sym} 2660 4160 0 0 {name=l3709 lab=VDD}
C {devices/lab_pin.sym} 2660 4240 0 0 {name=l3710 lab=VSS}
C {devices/lab_pin.sym} 2980 4160 0 0 {name=l3711 lab=VDD}
C {devices/lab_pin.sym} 2980 4240 0 0 {name=l3712 lab=VSS}
C {devices/lab_pin.sym} 3300 4160 0 0 {name=l3713 lab=VDD}
C {devices/lab_pin.sym} 3300 4240 0 0 {name=l3714 lab=VSS}
C {devices/lab_pin.sym} 3620 4160 0 0 {name=l3715 lab=VDD}
C {devices/lab_pin.sym} 3620 4240 0 0 {name=l3716 lab=VSS}
C {devices/lab_pin.sym} 3940 4160 0 0 {name=l3717 lab=VDD}
C {devices/lab_pin.sym} 3940 4240 0 0 {name=l3718 lab=VSS}
C {devices/lab_pin.sym} 4260 4160 0 0 {name=l3719 lab=VDD}
C {devices/lab_pin.sym} 4260 4240 0 0 {name=l3720 lab=VSS}
C {devices/lab_pin.sym} 4580 4160 0 0 {name=l3721 lab=VDD}
C {devices/lab_pin.sym} 4580 4240 0 0 {name=l3722 lab=VSS}
C {devices/lab_pin.sym} 4900 4160 0 0 {name=l3723 lab=VDD}
C {devices/lab_pin.sym} 4900 4240 0 0 {name=l3724 lab=VSS}
C {devices/lab_pin.sym} 5220 4160 0 0 {name=l3725 lab=VDD}
C {devices/lab_pin.sym} 5220 4240 0 0 {name=l3726 lab=VSS}
C {devices/lab_pin.sym} 5540 4160 0 0 {name=l3727 lab=VDD}
C {devices/lab_pin.sym} 5540 4240 0 0 {name=l3728 lab=VSS}
C {devices/lab_pin.sym} 5860 4160 0 0 {name=l3729 lab=VDD}
C {devices/lab_pin.sym} 5860 4240 0 0 {name=l3730 lab=VSS}
C {devices/lab_pin.sym} 6180 4160 0 0 {name=l3731 lab=VDD}
C {devices/lab_pin.sym} 6180 4240 0 0 {name=l3732 lab=VSS}
C {devices/lab_pin.sym} 6500 4160 0 0 {name=l3733 lab=VDD}
C {devices/lab_pin.sym} 6500 4240 0 0 {name=l3734 lab=VSS}
C {devices/lab_pin.sym} 6820 4160 0 0 {name=l3735 lab=VDD}
C {devices/lab_pin.sym} 6820 4240 0 0 {name=l3736 lab=VSS}
C {devices/lab_pin.sym} 7140 4160 0 0 {name=l3737 lab=VDD}
C {devices/lab_pin.sym} 7140 4240 0 0 {name=l3738 lab=VSS}
C {devices/lab_pin.sym} 7460 4160 0 0 {name=l3739 lab=VDD}
C {devices/lab_pin.sym} 7460 4240 0 0 {name=l3740 lab=VSS}
C {devices/lab_pin.sym} 7780 4160 0 0 {name=l3741 lab=VDD}
C {devices/lab_pin.sym} 7780 4240 0 0 {name=l3742 lab=VSS}
C {devices/lab_pin.sym} 8100 4160 0 0 {name=l3743 lab=VDD}
C {devices/lab_pin.sym} 8100 4240 0 0 {name=l3744 lab=VSS}
C {devices/lab_pin.sym} 8420 4160 0 0 {name=l3745 lab=VDD}
C {devices/lab_pin.sym} 8420 4240 0 0 {name=l3746 lab=VSS}
C {devices/lab_pin.sym} 8740 4160 0 0 {name=l3747 lab=VDD}
C {devices/lab_pin.sym} 8740 4240 0 0 {name=l3748 lab=VSS}
C {devices/lab_pin.sym} 9060 4160 0 0 {name=l3749 lab=VDD}
C {devices/lab_pin.sym} 9060 4240 0 0 {name=l3750 lab=VSS}
C {devices/lab_pin.sym} 9380 4160 0 0 {name=l3751 lab=VDD}
C {devices/lab_pin.sym} 9380 4240 0 0 {name=l3752 lab=VSS}
C {devices/lab_pin.sym} 9700 4160 0 0 {name=l3753 lab=VDD}
C {devices/lab_pin.sym} 9700 4240 0 0 {name=l3754 lab=VSS}
C {devices/lab_pin.sym} 10020 4160 0 0 {name=l3755 lab=VDD}
C {devices/lab_pin.sym} 10020 4240 0 0 {name=l3756 lab=VSS}
