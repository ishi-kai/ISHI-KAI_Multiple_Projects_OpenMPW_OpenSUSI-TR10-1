v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
T {ADDR_PREDEC V3 — 4-row compact / fully wired / no remote labels / GDS-aware} 400 80 0 0 0.3 0.3 {}
T {Four physical rows: two high-decode rows + two low-decode rows; two DFFS per row.} 400 130 0 0 0.18 0.18 {}
T {DFF3.Q -> DFF4.D is the only non-adjacent-row serial hop and is routed around the left perimeter.} 400 180 0 0 0.18 0.18 {}
T {HG/L_N remain on the right edge toward the top-level M2 control distribution corridor.} 400 230 0 0 0.18 0.18 {}
T {ROW0: DFF4/5 + HDEC/HG 0,2..7} 1200 1050 0 0 0.14 0.14 {}
T {ROW1: DFF6/7 + SEL_EN INV + HDEC/HG 8..13} 1200 2250 0 0 0.14 0.14 {}
T {ROW2: DFF0/1 + LDEC 0..7} 1200 3450 0 0 0.14 0.14 {}
T {ROW3: DFF2/3 + LDEC 8..15} 1200 4650 0 0 0.14 0.14 {}
N 400 500 700 500 {lab=VDD}
N 700 500 700 4700 {lab=VDD}
N 700 1100 16000 1100 {lab=VDD}
N 2170 1100 2170 1140 {lab=VDD}
N 3570 1100 3570 1140 {lab=VDD}
N 5430 1100 5430 1140 {lab=VDD}
N 5930 1100 5930 1140 {lab=VDD}
N 6930 1100 6930 1140 {lab=VDD}
N 7430 1100 7430 1140 {lab=VDD}
N 8430 1100 8430 1140 {lab=VDD}
N 8930 1100 8930 1140 {lab=VDD}
N 9930 1100 9930 1140 {lab=VDD}
N 10430 1100 10430 1140 {lab=VDD}
N 11430 1100 11430 1140 {lab=VDD}
N 11930 1100 11930 1140 {lab=VDD}
N 12930 1100 12930 1140 {lab=VDD}
N 13430 1100 13430 1140 {lab=VDD}
N 14430 1100 14430 1140 {lab=VDD}
N 14930 1100 14930 1140 {lab=VDD}
N 700 2300 16000 2300 {lab=VDD}
N 2170 2300 2170 2340 {lab=VDD}
N 3570 2300 3570 2340 {lab=VDD}
N 4830 2300 4830 2360 {lab=VDD}
N 6230 2300 6230 2340 {lab=VDD}
N 6730 2300 6730 2340 {lab=VDD}
N 7730 2300 7730 2340 {lab=VDD}
N 8230 2300 8230 2340 {lab=VDD}
N 9230 2300 9230 2340 {lab=VDD}
N 9730 2300 9730 2340 {lab=VDD}
N 10730 2300 10730 2340 {lab=VDD}
N 11230 2300 11230 2340 {lab=VDD}
N 12230 2300 12230 2340 {lab=VDD}
N 12730 2300 12730 2340 {lab=VDD}
N 13730 2300 13730 2340 {lab=VDD}
N 14230 2300 14230 2340 {lab=VDD}
N 700 3500 16000 3500 {lab=VDD}
N 2170 3500 2170 3540 {lab=VDD}
N 3570 3500 3570 3540 {lab=VDD}
N 5430 3500 5430 3540 {lab=VDD}
N 6630 3500 6630 3540 {lab=VDD}
N 7830 3500 7830 3540 {lab=VDD}
N 9030 3500 9030 3540 {lab=VDD}
N 10230 3500 10230 3540 {lab=VDD}
N 11430 3500 11430 3540 {lab=VDD}
N 12630 3500 12630 3540 {lab=VDD}
N 13830 3500 13830 3540 {lab=VDD}
N 700 4700 16000 4700 {lab=VDD}
N 2170 4700 2170 4740 {lab=VDD}
N 3570 4700 3570 4740 {lab=VDD}
N 5430 4700 5430 4740 {lab=VDD}
N 6630 4700 6630 4740 {lab=VDD}
N 7830 4700 7830 4740 {lab=VDD}
N 9030 4700 9030 4740 {lab=VDD}
N 10230 4700 10230 4740 {lab=VDD}
N 11430 4700 11430 4740 {lab=VDD}
N 12630 4700 12630 4740 {lab=VDD}
N 13830 4700 13830 4740 {lab=VDD}
N 2200 3640 2270 3640 {lab=VDD}
N 2270 3500 2270 3640 {lab=VDD}
N 3600 3640 3670 3640 {lab=VDD}
N 3670 3500 3670 3640 {lab=VDD}
N 2200 4840 2270 4840 {lab=VDD}
N 2270 4700 2270 4840 {lab=VDD}
N 3600 4840 3670 4840 {lab=VDD}
N 3670 4700 3670 4840 {lab=VDD}
N 2200 1240 2270 1240 {lab=VDD}
N 2270 1100 2270 1240 {lab=VDD}
N 3600 1240 3670 1240 {lab=VDD}
N 3670 1100 3670 1240 {lab=VDD}
N 2200 2440 2270 2440 {lab=VDD}
N 2270 2300 2270 2440 {lab=VDD}
N 3600 2440 3670 2440 {lab=VDD}
N 3670 2300 3670 2440 {lab=VDD}
N 400 5550 900 5550 {lab=VSS}
N 900 1300 900 5550 {lab=VSS}
N 900 1300 16000 1300 {lab=VSS}
N 2170 1260 2170 1300 {lab=VSS}
N 3570 1260 3570 1300 {lab=VSS}
N 5430 1260 5430 1300 {lab=VSS}
N 5930 1260 5930 1300 {lab=VSS}
N 6930 1260 6930 1300 {lab=VSS}
N 7430 1260 7430 1300 {lab=VSS}
N 8430 1260 8430 1300 {lab=VSS}
N 8930 1260 8930 1300 {lab=VSS}
N 9930 1260 9930 1300 {lab=VSS}
N 10430 1260 10430 1300 {lab=VSS}
N 11430 1260 11430 1300 {lab=VSS}
N 11930 1260 11930 1300 {lab=VSS}
N 12930 1260 12930 1300 {lab=VSS}
N 13430 1260 13430 1300 {lab=VSS}
N 14430 1260 14430 1300 {lab=VSS}
N 14930 1260 14930 1300 {lab=VSS}
N 900 2500 16000 2500 {lab=VSS}
N 2170 2460 2170 2500 {lab=VSS}
N 3570 2460 3570 2500 {lab=VSS}
N 4830 2440 4830 2500 {lab=VSS}
N 6230 2460 6230 2500 {lab=VSS}
N 6730 2460 6730 2500 {lab=VSS}
N 7730 2460 7730 2500 {lab=VSS}
N 8230 2460 8230 2500 {lab=VSS}
N 9230 2460 9230 2500 {lab=VSS}
N 9730 2460 9730 2500 {lab=VSS}
N 10730 2460 10730 2500 {lab=VSS}
N 11230 2460 11230 2500 {lab=VSS}
N 12230 2460 12230 2500 {lab=VSS}
N 12730 2460 12730 2500 {lab=VSS}
N 13730 2460 13730 2500 {lab=VSS}
N 14230 2460 14230 2500 {lab=VSS}
N 900 3700 16000 3700 {lab=VSS}
N 2170 3660 2170 3700 {lab=VSS}
N 3570 3660 3570 3700 {lab=VSS}
N 5430 3660 5430 3700 {lab=VSS}
N 6630 3660 6630 3700 {lab=VSS}
N 7830 3660 7830 3700 {lab=VSS}
N 9030 3660 9030 3700 {lab=VSS}
N 10230 3660 10230 3700 {lab=VSS}
N 11430 3660 11430 3700 {lab=VSS}
N 12630 3660 12630 3700 {lab=VSS}
N 13830 3660 13830 3700 {lab=VSS}
N 900 4900 16000 4900 {lab=VSS}
N 2170 4860 2170 4900 {lab=VSS}
N 3570 4860 3570 4900 {lab=VSS}
N 5430 4860 5430 4900 {lab=VSS}
N 6630 4860 6630 4900 {lab=VSS}
N 7830 4860 7830 4900 {lab=VSS}
N 9030 4860 9030 4900 {lab=VSS}
N 10230 4860 10230 4900 {lab=VSS}
N 11430 4860 11430 4900 {lab=VSS}
N 12630 4860 12630 4900 {lab=VSS}
N 13830 4860 13830 4900 {lab=VSS}
N 400 700 1100 700 {lab=SEL_CLK}
N 1100 700 1100 5100 {lab=SEL_CLK}
N 2100 1210 2170 1210 {lab=SEL_CLK}
N 2100 1210 2100 1500 {lab=SEL_CLK}
N 3470 1210 3570 1210 {lab=SEL_CLK}
N 3470 1210 3470 1500 {lab=SEL_CLK}
N 1100 1500 3470 1500 {lab=SEL_CLK}
N 2100 2410 2170 2410 {lab=SEL_CLK}
N 2100 2410 2100 2700 {lab=SEL_CLK}
N 3470 2410 3570 2410 {lab=SEL_CLK}
N 3470 2410 3470 2700 {lab=SEL_CLK}
N 1100 2700 3470 2700 {lab=SEL_CLK}
N 2100 3610 2170 3610 {lab=SEL_CLK}
N 2100 3610 2100 3900 {lab=SEL_CLK}
N 3470 3610 3570 3610 {lab=SEL_CLK}
N 3470 3610 3470 3900 {lab=SEL_CLK}
N 1100 3900 3470 3900 {lab=SEL_CLK}
N 2100 4810 2170 4810 {lab=SEL_CLK}
N 2100 4810 2100 5100 {lab=SEL_CLK}
N 3470 4810 3570 4810 {lab=SEL_CLK}
N 3470 4810 3470 5100 {lab=SEL_CLK}
N 1100 5100 3470 5100 {lab=SEL_CLK}
N 400 3570 2170 3570 {lab=SEL_DATA}
N 400 2400 4780 2400 {lab=SEL_EN}
N 2230 3570 2290 3570 {lab=#net1}
N 2290 3570 2290 4050 {lab=#net1}
N 3500 3570 3570 3570 {lab=#net1}
N 3500 3570 3500 4050 {lab=#net1}
N 6400 3630 6580 3630 {lab=#net1}
N 6400 3630 6400 4050 {lab=#net1}
N 8800 3630 8980 3630 {lab=#net1}
N 8800 3630 8800 4050 {lab=#net1}
N 11200 3630 11380 3630 {lab=#net1}
N 11200 3630 11200 4050 {lab=#net1}
N 13600 3630 13780 3630 {lab=#net1}
N 13600 3630 13600 4050 {lab=#net1}
N 6400 4830 6580 4830 {lab=#net1}
N 6400 4050 6400 4830 {lab=#net1}
N 8800 4830 8980 4830 {lab=#net1}
N 8800 4050 8800 4830 {lab=#net1}
N 11200 4830 11380 4830 {lab=#net1}
N 11200 4050 11200 4830 {lab=#net1}
N 13600 4830 13780 4830 {lab=#net1}
N 13600 4050 13600 4830 {lab=#net1}
N 2290 4050 13600 4050 {lab=#net1}
N 2230 3610 2320 3610 {lab=#net2}
N 2320 3610 2320 4090 {lab=#net2}
N 5180 3630 5380 3630 {lab=#net2}
N 5180 3630 5180 4090 {lab=#net2}
N 7580 3630 7780 3630 {lab=#net2}
N 7580 3630 7580 4090 {lab=#net2}
N 9980 3630 10180 3630 {lab=#net2}
N 9980 3630 9980 4090 {lab=#net2}
N 12380 3630 12580 3630 {lab=#net2}
N 12380 3630 12380 4090 {lab=#net2}
N 5180 4830 5380 4830 {lab=#net2}
N 5180 4090 5180 4830 {lab=#net2}
N 7580 4830 7780 4830 {lab=#net2}
N 7580 4090 7580 4830 {lab=#net2}
N 9980 4830 10180 4830 {lab=#net2}
N 9980 4090 9980 4830 {lab=#net2}
N 12380 4830 12580 4830 {lab=#net2}
N 12380 4090 12380 4830 {lab=#net2}
N 2320 4090 12380 4090 {lab=#net2}
N 3630 3570 3690 3570 {lab=#net3}
N 3690 3570 3690 4130 {lab=#net3}
N 2100 4770 2170 4770 {lab=#net3}
N 2100 4130 2100 4770 {lab=#net3}
N 7640 3610 7780 3610 {lab=#net3}
N 7640 3610 7640 4130 {lab=#net3}
N 8840 3610 8980 3610 {lab=#net3}
N 8840 3610 8840 4130 {lab=#net3}
N 12440 3610 12580 3610 {lab=#net3}
N 12440 3610 12440 4130 {lab=#net3}
N 13640 3610 13780 3610 {lab=#net3}
N 13640 3610 13640 4130 {lab=#net3}
N 7640 4810 7780 4810 {lab=#net3}
N 7640 4130 7640 4810 {lab=#net3}
N 8840 4810 8980 4810 {lab=#net3}
N 8840 4130 8840 4810 {lab=#net3}
N 12440 4810 12580 4810 {lab=#net3}
N 12440 4130 12440 4810 {lab=#net3}
N 13640 4810 13780 4810 {lab=#net3}
N 13640 4130 13640 4810 {lab=#net3}
N 2100 4130 13640 4130 {lab=#net3}
N 3630 3610 3720 3610 {lab=#net4}
N 3720 3610 3720 4170 {lab=#net4}
N 5220 3610 5380 3610 {lab=#net4}
N 5220 3610 5220 4170 {lab=#net4}
N 6420 3610 6580 3610 {lab=#net4}
N 6420 3610 6420 4170 {lab=#net4}
N 10020 3610 10180 3610 {lab=#net4}
N 10020 3610 10020 4170 {lab=#net4}
N 11220 3610 11380 3610 {lab=#net4}
N 11220 3610 11220 4170 {lab=#net4}
N 5220 4810 5380 4810 {lab=#net4}
N 5220 4170 5220 4810 {lab=#net4}
N 6420 4810 6580 4810 {lab=#net4}
N 6420 4170 6420 4810 {lab=#net4}
N 10020 4810 10180 4810 {lab=#net4}
N 10020 4170 10020 4810 {lab=#net4}
N 11220 4810 11380 4810 {lab=#net4}
N 11220 4170 11220 4810 {lab=#net4}
N 3720 4170 11220 4170 {lab=#net4}
N 2230 4770 2290 4770 {lab=#net5}
N 2290 4210 2290 4770 {lab=#net5}
N 3500 4770 3570 4770 {lab=#net5}
N 3500 4210 3500 4770 {lab=#net5}
N 10080 3590 10180 3590 {lab=#net5}
N 10080 3590 10080 4210 {lab=#net5}
N 11280 3590 11380 3590 {lab=#net5}
N 11280 3590 11280 4210 {lab=#net5}
N 12480 3590 12580 3590 {lab=#net5}
N 12480 3590 12480 4210 {lab=#net5}
N 13680 3590 13780 3590 {lab=#net5}
N 13680 3590 13680 4210 {lab=#net5}
N 10080 4790 10180 4790 {lab=#net5}
N 10080 4210 10080 4790 {lab=#net5}
N 11280 4790 11380 4790 {lab=#net5}
N 11280 4210 11280 4790 {lab=#net5}
N 12480 4790 12580 4790 {lab=#net5}
N 12480 4210 12480 4790 {lab=#net5}
N 13680 4790 13780 4790 {lab=#net5}
N 13680 4210 13680 4790 {lab=#net5}
N 2290 4210 13680 4210 {lab=#net5}
N 2230 4810 2320 4810 {lab=#net6}
N 2320 4250 2320 4810 {lab=#net6}
N 5260 3590 5380 3590 {lab=#net6}
N 5260 3590 5260 4250 {lab=#net6}
N 6460 3590 6580 3590 {lab=#net6}
N 6460 3590 6460 4250 {lab=#net6}
N 7660 3590 7780 3590 {lab=#net6}
N 7660 3590 7660 4250 {lab=#net6}
N 8860 3590 8980 3590 {lab=#net6}
N 8860 3590 8860 4250 {lab=#net6}
N 5260 4790 5380 4790 {lab=#net6}
N 5260 4250 5260 4790 {lab=#net6}
N 6460 4790 6580 4790 {lab=#net6}
N 6460 4250 6460 4790 {lab=#net6}
N 7660 4790 7780 4790 {lab=#net6}
N 7660 4250 7660 4790 {lab=#net6}
N 8860 4790 8980 4790 {lab=#net6}
N 8860 4250 8860 4790 {lab=#net6}
N 2320 4250 8860 4250 {lab=#net6}
N 3630 4770 3690 4770 {lab=#net7}
N 3690 4290 3690 4770 {lab=#net7}
N 1300 4290 1450 4290 {lab=#net7}
N 1450 1170 1450 4290 {lab=#net7}
N 1450 1170 2170 1170 {lab=#net7}
N 5320 4770 5380 4770 {lab=#net7}
N 5320 4290 5320 4770 {lab=#net7}
N 6520 4770 6580 4770 {lab=#net7}
N 6520 4290 6520 4770 {lab=#net7}
N 7720 4770 7780 4770 {lab=#net7}
N 7720 4290 7720 4770 {lab=#net7}
N 8920 4770 8980 4770 {lab=#net7}
N 8920 4290 8920 4770 {lab=#net7}
N 10120 4770 10180 4770 {lab=#net7}
N 10120 4290 10120 4770 {lab=#net7}
N 11320 4770 11380 4770 {lab=#net7}
N 11320 4290 11320 4770 {lab=#net7}
N 12520 4770 12580 4770 {lab=#net7}
N 12520 4290 12520 4770 {lab=#net7}
N 13720 4770 13780 4770 {lab=#net7}
N 13720 4290 13720 4770 {lab=#net7}
N 1300 4290 13720 4290 {lab=#net7}
N 3630 4810 3720 4810 {lab=#net8}
N 3720 4330 3720 4810 {lab=#net8}
N 5300 3570 5380 3570 {lab=#net8}
N 5300 3570 5300 4330 {lab=#net8}
N 6500 3570 6580 3570 {lab=#net8}
N 6500 3570 6500 4330 {lab=#net8}
N 7700 3570 7780 3570 {lab=#net8}
N 7700 3570 7700 4330 {lab=#net8}
N 8900 3570 8980 3570 {lab=#net8}
N 8900 3570 8900 4330 {lab=#net8}
N 10100 3570 10180 3570 {lab=#net8}
N 10100 3570 10100 4330 {lab=#net8}
N 11300 3570 11380 3570 {lab=#net8}
N 11300 3570 11300 4330 {lab=#net8}
N 12500 3570 12580 3570 {lab=#net8}
N 12500 3570 12500 4330 {lab=#net8}
N 13700 3570 13780 3570 {lab=#net8}
N 13700 3570 13700 4330 {lab=#net8}
N 3720 4330 13700 4330 {lab=#net8}
N 2230 1170 2290 1170 {lab=#net9}
N 2290 1170 2290 1650 {lab=#net9}
N 3500 1170 3570 1170 {lab=#net9}
N 3500 1170 3500 1650 {lab=#net9}
N 8200 1230 8380 1230 {lab=#net9}
N 8200 1230 8200 1650 {lab=#net9}
N 11200 1230 11380 1230 {lab=#net9}
N 11200 1230 11200 1650 {lab=#net9}
N 14200 1230 14380 1230 {lab=#net9}
N 14200 1230 14200 1650 {lab=#net9}
N 7500 2430 7680 2430 {lab=#net9}
N 7500 1650 7500 2430 {lab=#net9}
N 10500 2430 10680 2430 {lab=#net9}
N 10500 1650 10500 2430 {lab=#net9}
N 13500 2430 13680 2430 {lab=#net9}
N 13500 1650 13500 2430 {lab=#net9}
N 2290 1650 14200 1650 {lab=#net9}
N 2230 1210 2320 1210 {lab=#net10}
N 2320 1210 2320 1690 {lab=#net10}
N 5180 1230 5380 1230 {lab=#net10}
N 5180 1230 5180 1690 {lab=#net10}
N 6680 1230 6880 1230 {lab=#net10}
N 6680 1230 6680 1690 {lab=#net10}
N 9680 1230 9880 1230 {lab=#net10}
N 9680 1230 9680 1690 {lab=#net10}
N 12680 1230 12880 1230 {lab=#net10}
N 12680 1230 12680 1690 {lab=#net10}
N 5980 2430 6180 2430 {lab=#net10}
N 5980 1690 5980 2430 {lab=#net10}
N 8980 2430 9180 2430 {lab=#net10}
N 8980 1690 8980 2430 {lab=#net10}
N 11980 2430 12180 2430 {lab=#net10}
N 11980 1690 11980 2430 {lab=#net10}
N 2320 1690 12680 1690 {lab=#net10}
N 3630 1170 3690 1170 {lab=#net11}
N 3690 1170 3690 1730 {lab=#net11}
N 2100 2370 2170 2370 {lab=#net11}
N 2100 1730 2100 2370 {lab=#net11}
N 6740 1210 6880 1210 {lab=#net11}
N 6740 1210 6740 1730 {lab=#net11}
N 8240 1210 8380 1210 {lab=#net11}
N 8240 1210 8240 1730 {lab=#net11}
N 12740 1210 12880 1210 {lab=#net11}
N 12740 1210 12740 1730 {lab=#net11}
N 14240 1210 14380 1210 {lab=#net11}
N 14240 1210 14240 1730 {lab=#net11}
N 9040 2410 9180 2410 {lab=#net11}
N 9040 1730 9040 2410 {lab=#net11}
N 10540 2410 10680 2410 {lab=#net11}
N 10540 1730 10540 2410 {lab=#net11}
N 2100 1730 14240 1730 {lab=#net11}
N 3630 1210 3720 1210 {lab=#net12}
N 3720 1210 3720 1770 {lab=#net12}
N 5220 1210 5380 1210 {lab=#net12}
N 5220 1210 5220 1770 {lab=#net12}
N 9720 1210 9880 1210 {lab=#net12}
N 9720 1210 9720 1770 {lab=#net12}
N 11220 1210 11380 1210 {lab=#net12}
N 11220 1210 11220 1770 {lab=#net12}
N 6020 2410 6180 2410 {lab=#net12}
N 6020 1770 6020 2410 {lab=#net12}
N 7520 2410 7680 2410 {lab=#net12}
N 7520 1770 7520 2410 {lab=#net12}
N 12020 2410 12180 2410 {lab=#net12}
N 12020 1770 12020 2410 {lab=#net12}
N 13520 2410 13680 2410 {lab=#net12}
N 13520 1770 13520 2410 {lab=#net12}
N 3720 1770 13520 1770 {lab=#net12}
N 2230 2370 2290 2370 {lab=#net13}
N 2290 1810 2290 2370 {lab=#net13}
N 3500 2370 3570 2370 {lab=#net13}
N 3500 1810 3500 2370 {lab=#net13}
N 9780 1190 9880 1190 {lab=#net13}
N 9780 1190 9780 1810 {lab=#net13}
N 11280 1190 11380 1190 {lab=#net13}
N 11280 1190 11280 1810 {lab=#net13}
N 12780 1190 12880 1190 {lab=#net13}
N 12780 1190 12780 1810 {lab=#net13}
N 14280 1190 14380 1190 {lab=#net13}
N 14280 1190 14280 1810 {lab=#net13}
N 12080 2390 12180 2390 {lab=#net13}
N 12080 1810 12080 2390 {lab=#net13}
N 13580 2390 13680 2390 {lab=#net13}
N 13580 1810 13580 2390 {lab=#net13}
N 2290 1810 14280 1810 {lab=#net13}
N 2230 2410 2320 2410 {lab=#net14}
N 2320 1850 2320 2410 {lab=#net14}
N 5260 1190 5380 1190 {lab=#net14}
N 5260 1190 5260 1850 {lab=#net14}
N 6760 1190 6880 1190 {lab=#net14}
N 6760 1190 6760 1850 {lab=#net14}
N 8260 1190 8380 1190 {lab=#net14}
N 8260 1190 8260 1850 {lab=#net14}
N 6060 2390 6180 2390 {lab=#net14}
N 6060 1850 6060 2390 {lab=#net14}
N 7560 2390 7680 2390 {lab=#net14}
N 7560 1850 7560 2390 {lab=#net14}
N 9060 2390 9180 2390 {lab=#net14}
N 9060 1850 9060 2390 {lab=#net14}
N 10560 2390 10680 2390 {lab=#net14}
N 10560 1850 10560 2390 {lab=#net14}
N 2320 1850 10560 1850 {lab=#net14}
N 3630 2370 3690 2370 {lab=#net15}
N 3690 1890 3690 2370 {lab=#net15}
N 6120 2370 6180 2370 {lab=#net15}
N 6120 1890 6120 2370 {lab=#net15}
N 7620 2370 7680 2370 {lab=#net15}
N 7620 1890 7620 2370 {lab=#net15}
N 9120 2370 9180 2370 {lab=#net15}
N 9120 1890 9120 2370 {lab=#net15}
N 10620 2370 10680 2370 {lab=#net15}
N 10620 1890 10620 2370 {lab=#net15}
N 12120 2370 12180 2370 {lab=#net15}
N 12120 1890 12120 2370 {lab=#net15}
N 13620 2370 13680 2370 {lab=#net15}
N 13620 1890 13620 2370 {lab=#net15}
N 3690 1890 13620 1890 {lab=#net15}
N 3630 2410 3720 2410 {lab=#net16}
N 3720 1930 3720 2410 {lab=#net16}
N 5300 1170 5380 1170 {lab=#net16}
N 5300 1170 5300 1930 {lab=#net16}
N 6800 1170 6880 1170 {lab=#net16}
N 6800 1170 6800 1930 {lab=#net16}
N 8300 1170 8380 1170 {lab=#net16}
N 8300 1170 8300 1930 {lab=#net16}
N 9800 1170 9880 1170 {lab=#net16}
N 9800 1170 9800 1930 {lab=#net16}
N 11300 1170 11380 1170 {lab=#net16}
N 11300 1170 11300 1930 {lab=#net16}
N 12800 1170 12880 1170 {lab=#net16}
N 12800 1170 12800 1930 {lab=#net16}
N 14300 1170 14380 1170 {lab=#net16}
N 14300 1170 14300 1930 {lab=#net16}
N 3720 1930 14300 1930 {lab=#net16}
N 4900 2400 5000 2400 {lab=#net17}
N 5000 2010 5000 2400 {lab=#net17}
N 5790 1180 5880 1180 {lab=#net17}
N 5790 1220 5790 2010 {lab=#net17}
N 7290 1180 7380 1180 {lab=#net17}
N 7290 1220 7290 2010 {lab=#net17}
N 8790 1180 8880 1180 {lab=#net17}
N 8790 1220 8790 2010 {lab=#net17}
N 10290 1180 10380 1180 {lab=#net17}
N 10290 1220 10290 2010 {lab=#net17}
N 11790 1180 11880 1180 {lab=#net17}
N 11790 1220 11790 2010 {lab=#net17}
N 13290 1180 13380 1180 {lab=#net17}
N 13290 1220 13290 2010 {lab=#net17}
N 14790 1180 14880 1180 {lab=#net17}
N 14790 1220 14790 2010 {lab=#net17}
N 6590 2420 6680 2420 {lab=#net17}
N 6590 2010 6590 2420 {lab=#net17}
N 8090 2420 8180 2420 {lab=#net17}
N 8090 2010 8090 2420 {lab=#net17}
N 9590 2420 9680 2420 {lab=#net17}
N 9590 2010 9590 2420 {lab=#net17}
N 11090 2420 11180 2420 {lab=#net17}
N 11090 2010 11090 2420 {lab=#net17}
N 12590 2420 12680 2420 {lab=#net17}
N 12590 2010 12590 2420 {lab=#net17}
N 14090 2420 14180 2420 {lab=#net17}
N 14090 2010 14090 2420 {lab=#net17}
N 5000 2010 14790 2010 {lab=#net17}
N 5530 1200 5650 1200 {lab=#net18}
N 5880 1200 5880 1220 {lab=#net18}
N 5650 1200 5880 1200 {lab=#net18}
N 7030 1200 7150 1200 {lab=#net19}
N 7380 1200 7380 1220 {lab=#net19}
N 7150 1200 7380 1200 {lab=#net19}
N 8530 1200 8650 1200 {lab=#net20}
N 8880 1200 8880 1220 {lab=#net20}
N 8650 1200 8880 1200 {lab=#net20}
N 10030 1200 10150 1200 {lab=#net21}
N 10380 1200 10380 1220 {lab=#net21}
N 10150 1200 10380 1200 {lab=#net21}
N 11530 1200 11650 1200 {lab=#net22}
N 11880 1200 11880 1220 {lab=#net22}
N 11650 1200 11880 1200 {lab=#net22}
N 13030 1200 13150 1200 {lab=#net23}
N 13380 1200 13380 1220 {lab=#net23}
N 13150 1200 13380 1200 {lab=#net23}
N 14530 1200 14650 1200 {lab=#net24}
N 14880 1200 14880 1220 {lab=#net24}
N 14650 1200 14880 1200 {lab=#net24}
N 6330 2400 6450 2400 {lab=#net25}
N 6450 2380 6450 2400 {lab=#net25}
N 6450 2380 6680 2380 {lab=#net25}
N 7830 2400 7950 2400 {lab=#net26}
N 7950 2380 7950 2400 {lab=#net26}
N 7950 2380 8180 2380 {lab=#net26}
N 9330 2400 9450 2400 {lab=#net27}
N 9450 2380 9450 2400 {lab=#net27}
N 9450 2380 9680 2380 {lab=#net27}
N 10830 2400 10950 2400 {lab=#net28}
N 10950 2380 10950 2400 {lab=#net28}
N 10950 2380 11180 2380 {lab=#net28}
N 12330 2400 12450 2400 {lab=#net29}
N 12450 2380 12450 2400 {lab=#net29}
N 12450 2380 12680 2380 {lab=#net29}
N 13830 2400 13950 2400 {lab=#net30}
N 13950 2380 13950 2400 {lab=#net30}
N 13950 2380 14180 2380 {lab=#net30}
N 6010 1200 6130 1200 {lab=HG0}
N 6130 620 6130 1200 {lab=HG0}
N 6130 620 17000 620 {lab=HG0}
N 7510 1200 7670 1200 {lab=HG2}
N 7670 680 7670 1200 {lab=HG2}
N 7670 680 17000 680 {lab=HG2}
N 9010 1200 9130 1200 {lab=HG3}
N 9130 740 9130 1200 {lab=HG3}
N 9130 740 17000 740 {lab=HG3}
N 10510 1200 10650 1200 {lab=HG4}
N 10650 800 10650 1200 {lab=HG4}
N 10650 800 17000 800 {lab=HG4}
N 12010 1200 12170 1200 {lab=HG5}
N 12170 860 12170 1200 {lab=HG5}
N 12170 860 17000 860 {lab=HG5}
N 13510 1200 13630 1200 {lab=HG6}
N 13630 920 13630 1200 {lab=HG6}
N 13630 920 17000 920 {lab=HG6}
N 15010 1200 15150 1200 {lab=HG7}
N 15150 980 15150 1200 {lab=HG7}
N 15150 980 17000 980 {lab=HG7}
N 6810 2400 6970 2400 {lab=HG8}
N 6970 2400 6970 2700 {lab=HG8}
N 6970 2700 17000 2700 {lab=HG8}
N 8310 2400 8430 2400 {lab=HG9}
N 8430 2400 8430 2760 {lab=HG9}
N 8430 2760 17000 2760 {lab=HG9}
N 9810 2400 9950 2400 {lab=HG10}
N 9950 2400 9950 2820 {lab=HG10}
N 9950 2820 17000 2820 {lab=HG10}
N 11310 2400 11470 2400 {lab=HG11}
N 11470 2400 11470 2880 {lab=HG11}
N 11470 2880 17000 2880 {lab=HG11}
N 12810 2400 12930 2400 {lab=HG12}
N 12930 2400 12930 2940 {lab=HG12}
N 12930 2940 17000 2940 {lab=HG12}
N 14310 2400 14450 2400 {lab=HG13}
N 14450 2400 14450 3000 {lab=HG13}
N 14450 3000 17000 3000 {lab=HG13}
N 5530 3600 5690 3600 {lab=L_N0}
N 5690 3100 5690 3600 {lab=L_N0}
N 5690 3100 17000 3100 {lab=L_N0}
N 6730 3600 6910 3600 {lab=L_N1}
N 6910 3150 6910 3600 {lab=L_N1}
N 6910 3150 17000 3150 {lab=L_N1}
N 7930 3600 8130 3600 {lab=L_N2}
N 8130 3200 8130 3600 {lab=L_N2}
N 8130 3200 17000 3200 {lab=L_N2}
N 9130 3600 9350 3600 {lab=L_N3}
N 9350 3250 9350 3600 {lab=L_N3}
N 9350 3250 17000 3250 {lab=L_N3}
N 10330 3600 10490 3600 {lab=L_N4}
N 10490 3300 10490 3600 {lab=L_N4}
N 10490 3300 17000 3300 {lab=L_N4}
N 11530 3600 11710 3600 {lab=L_N5}
N 11710 3350 11710 3600 {lab=L_N5}
N 11710 3350 17000 3350 {lab=L_N5}
N 12730 3600 12930 3600 {lab=L_N6}
N 12930 3400 12930 3600 {lab=L_N6}
N 12930 3400 17000 3400 {lab=L_N6}
N 13930 3600 14150 3600 {lab=L_N7}
N 14150 3450 14150 3600 {lab=L_N7}
N 14150 3450 17000 3450 {lab=L_N7}
N 5530 4800 5690 4800 {lab=L_N8}
N 5690 4800 5690 5150 {lab=L_N8}
N 5690 5150 17000 5150 {lab=L_N8}
N 6730 4800 6910 4800 {lab=L_N9}
N 6910 4800 6910 5200 {lab=L_N9}
N 6910 5200 17000 5200 {lab=L_N9}
N 7930 4800 8130 4800 {lab=L_N10}
N 8130 4800 8130 5250 {lab=L_N10}
N 8130 5250 17000 5250 {lab=L_N10}
N 9130 4800 9350 4800 {lab=L_N11}
N 9350 4800 9350 5300 {lab=L_N11}
N 9350 5300 17000 5300 {lab=L_N11}
N 10330 4800 10490 4800 {lab=L_N12}
N 10490 4800 10490 5350 {lab=L_N12}
N 10490 5350 17000 5350 {lab=L_N12}
N 11530 4800 11710 4800 {lab=L_N13}
N 11710 4800 11710 5400 {lab=L_N13}
N 11710 5400 17000 5400 {lab=L_N13}
N 12730 4800 12930 4800 {lab=L_N14}
N 12930 4800 12930 5450 {lab=L_N14}
N 12930 5450 17000 5450 {lab=L_N14}
N 13930 4800 14150 4800 {lab=L_N15}
N 14150 4800 14150 5500 {lab=L_N15}
N 14150 5500 17000 5500 {lab=L_N15}
N 5790 1180 5790 1220 {lab=#net17}
N 7290 1180 7290 1220 {lab=#net17}
N 8790 1180 8790 1220 {lab=#net17}
N 10290 1180 10290 1220 {lab=#net17}
N 11790 1180 11790 1220 {lab=#net17}
N 13290 1180 13290 1220 {lab=#net17}
N 14790 1180 14790 1220 {lab=#net17}
C {TR-1um_5_stdcell/DFFS.sym} 2200 1200 0 0 {name=xREG_DFFS_4}
C {TR-1um_5_stdcell/DFFS.sym} 3600 1200 0 0 {name=xREG_DFFS_5}
C {TR-1um_5_stdcell/NAND4.sym} 5400 1200 0 0 {name=xHDEC_NAND4_0}
C {TR-1um_5_stdcell/OR2.sym} 5900 1200 0 0 {name=xHG_OR2_0}
C {TR-1um_5_stdcell/NAND4.sym} 6900 1200 0 0 {name=xHDEC_NAND4_2}
C {TR-1um_5_stdcell/OR2.sym} 7400 1200 0 0 {name=xHG_OR2_2}
C {TR-1um_5_stdcell/NAND4.sym} 8400 1200 0 0 {name=xHDEC_NAND4_3}
C {TR-1um_5_stdcell/OR2.sym} 8900 1200 0 0 {name=xHG_OR2_3}
C {TR-1um_5_stdcell/NAND4.sym} 9900 1200 0 0 {name=xHDEC_NAND4_4}
C {TR-1um_5_stdcell/OR2.sym} 10400 1200 0 0 {name=xHG_OR2_4}
C {TR-1um_5_stdcell/NAND4.sym} 11400 1200 0 0 {name=xHDEC_NAND4_5}
C {TR-1um_5_stdcell/OR2.sym} 11900 1200 0 0 {name=xHG_OR2_5}
C {TR-1um_5_stdcell/NAND4.sym} 12900 1200 0 0 {name=xHDEC_NAND4_6}
C {TR-1um_5_stdcell/OR2.sym} 13400 1200 0 0 {name=xHG_OR2_6}
C {TR-1um_5_stdcell/NAND4.sym} 14400 1200 0 0 {name=xHDEC_NAND4_7}
C {TR-1um_5_stdcell/OR2.sym} 14900 1200 0 0 {name=xHG_OR2_7}
C {TR-1um_5_stdcell/DFFS.sym} 2200 2400 0 0 {name=xREG_DFFS_6}
C {TR-1um_5_stdcell/DFFS.sym} 3600 2400 0 0 {name=xREG_DFFS_7}
C {TR-1um_5_stdcell/INV_X1.sym} 4800 2400 0 0 {name=xSEL_EN_INV}
C {TR-1um_5_stdcell/NAND4.sym} 6200 2400 0 0 {name=xHDEC_NAND4_8}
C {TR-1um_5_stdcell/OR2.sym} 6700 2400 0 0 {name=xHG_OR2_8}
C {TR-1um_5_stdcell/NAND4.sym} 7700 2400 0 0 {name=xHDEC_NAND4_9}
C {TR-1um_5_stdcell/OR2.sym} 8200 2400 0 0 {name=xHG_OR2_9}
C {TR-1um_5_stdcell/NAND4.sym} 9200 2400 0 0 {name=xHDEC_NAND4_10}
C {TR-1um_5_stdcell/OR2.sym} 9700 2400 0 0 {name=xHG_OR2_10}
C {TR-1um_5_stdcell/NAND4.sym} 10700 2400 0 0 {name=xHDEC_NAND4_11}
C {TR-1um_5_stdcell/OR2.sym} 11200 2400 0 0 {name=xHG_OR2_11}
C {TR-1um_5_stdcell/NAND4.sym} 12200 2400 0 0 {name=xHDEC_NAND4_12}
C {TR-1um_5_stdcell/OR2.sym} 12700 2400 0 0 {name=xHG_OR2_12}
C {TR-1um_5_stdcell/NAND4.sym} 13700 2400 0 0 {name=xHDEC_NAND4_13}
C {TR-1um_5_stdcell/OR2.sym} 14200 2400 0 0 {name=xHG_OR2_13}
C {TR-1um_5_stdcell/DFFS.sym} 2200 3600 0 0 {name=xREG_DFFS_0}
C {TR-1um_5_stdcell/DFFS.sym} 3600 3600 0 0 {name=xREG_DFFS_1}
C {TR-1um_5_stdcell/NAND4.sym} 5400 3600 0 0 {name=xLDEC_NAND4_0}
C {TR-1um_5_stdcell/NAND4.sym} 6600 3600 0 0 {name=xLDEC_NAND4_1}
C {TR-1um_5_stdcell/NAND4.sym} 7800 3600 0 0 {name=xLDEC_NAND4_2}
C {TR-1um_5_stdcell/NAND4.sym} 9000 3600 0 0 {name=xLDEC_NAND4_3}
C {TR-1um_5_stdcell/NAND4.sym} 10200 3600 0 0 {name=xLDEC_NAND4_4}
C {TR-1um_5_stdcell/NAND4.sym} 11400 3600 0 0 {name=xLDEC_NAND4_5}
C {TR-1um_5_stdcell/NAND4.sym} 12600 3600 0 0 {name=xLDEC_NAND4_6}
C {TR-1um_5_stdcell/NAND4.sym} 13800 3600 0 0 {name=xLDEC_NAND4_7}
C {TR-1um_5_stdcell/DFFS.sym} 2200 4800 0 0 {name=xREG_DFFS_2}
C {TR-1um_5_stdcell/DFFS.sym} 3600 4800 0 0 {name=xREG_DFFS_3}
C {TR-1um_5_stdcell/NAND4.sym} 5400 4800 0 0 {name=xLDEC_NAND4_8}
C {TR-1um_5_stdcell/NAND4.sym} 6600 4800 0 0 {name=xLDEC_NAND4_9}
C {TR-1um_5_stdcell/NAND4.sym} 7800 4800 0 0 {name=xLDEC_NAND4_10}
C {TR-1um_5_stdcell/NAND4.sym} 9000 4800 0 0 {name=xLDEC_NAND4_11}
C {TR-1um_5_stdcell/NAND4.sym} 10200 4800 0 0 {name=xLDEC_NAND4_12}
C {TR-1um_5_stdcell/NAND4.sym} 11400 4800 0 0 {name=xLDEC_NAND4_13}
C {TR-1um_5_stdcell/NAND4.sym} 12600 4800 0 0 {name=xLDEC_NAND4_14}
C {TR-1um_5_stdcell/NAND4.sym} 13800 4800 0 0 {name=xLDEC_NAND4_15}
C {devices/iopin.sym} 400 500 0 0 {name=pVDD lab=VDD}
C {devices/iopin.sym} 400 5550 0 0 {name=pVSS lab=VSS}
C {devices/ipin.sym} 400 3570 0 0 {name=pDATA lab=SEL_DATA}
C {devices/ipin.sym} 400 700 0 0 {name=pCLK lab=SEL_CLK}
C {devices/ipin.sym} 400 2400 0 0 {name=pEN lab=SEL_EN}
C {devices/opin.sym} 17000 620 0 0 {name=pHG_0 lab=HG0}
C {devices/opin.sym} 17000 680 0 0 {name=pHG_2 lab=HG2}
C {devices/opin.sym} 17000 740 0 0 {name=pHG_3 lab=HG3}
C {devices/opin.sym} 17000 800 0 0 {name=pHG_4 lab=HG4}
C {devices/opin.sym} 17000 860 0 0 {name=pHG_5 lab=HG5}
C {devices/opin.sym} 17000 920 0 0 {name=pHG_6 lab=HG6}
C {devices/opin.sym} 17000 980 0 0 {name=pHG_7 lab=HG7}
C {devices/opin.sym} 17000 2700 0 0 {name=pHG_8 lab=HG8}
C {devices/opin.sym} 17000 2760 0 0 {name=pHG_9 lab=HG9}
C {devices/opin.sym} 17000 2820 0 0 {name=pHG_10 lab=HG10}
C {devices/opin.sym} 17000 2880 0 0 {name=pHG_11 lab=HG11}
C {devices/opin.sym} 17000 2940 0 0 {name=pHG_12 lab=HG12}
C {devices/opin.sym} 17000 3000 0 0 {name=pHG_13 lab=HG13}
C {devices/opin.sym} 17000 3100 0 0 {name=pLN_0 lab=L_N0}
C {devices/opin.sym} 17000 3150 0 0 {name=pLN_1 lab=L_N1}
C {devices/opin.sym} 17000 3200 0 0 {name=pLN_2 lab=L_N2}
C {devices/opin.sym} 17000 3250 0 0 {name=pLN_3 lab=L_N3}
C {devices/opin.sym} 17000 3300 0 0 {name=pLN_4 lab=L_N4}
C {devices/opin.sym} 17000 3350 0 0 {name=pLN_5 lab=L_N5}
C {devices/opin.sym} 17000 3400 0 0 {name=pLN_6 lab=L_N6}
C {devices/opin.sym} 17000 3450 0 0 {name=pLN_7 lab=L_N7}
C {devices/opin.sym} 17000 5150 0 0 {name=pLN_8 lab=L_N8}
C {devices/opin.sym} 17000 5200 0 0 {name=pLN_9 lab=L_N9}
C {devices/opin.sym} 17000 5250 0 0 {name=pLN_10 lab=L_N10}
C {devices/opin.sym} 17000 5300 0 0 {name=pLN_11 lab=L_N11}
C {devices/opin.sym} 17000 5350 0 0 {name=pLN_12 lab=L_N12}
C {devices/opin.sym} 17000 5400 0 0 {name=pLN_13 lab=L_N13}
C {devices/opin.sym} 17000 5450 0 0 {name=pLN_14 lab=L_N14}
C {devices/opin.sym} 17000 5500 0 0 {name=pLN_15 lab=L_N15}
