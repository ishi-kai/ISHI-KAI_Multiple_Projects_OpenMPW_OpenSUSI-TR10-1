v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 120 -160 280 -160 {lab=INP}
N 120 -340 280 -340 {lab=INM}
N 340 -280 340 -220 {lab=GND}
N 300 -250 340 -250 {lab=GND}
N 140 -300 280 -300 {lab=SENSEM}
N 140 -200 280 -200 {lab=SENSEP}
N 120 -200 140 -200 {lab=SENSEP}
N 120 -300 140 -300 {lab=SENSEM}
N 140 -300 140 -270 {lab=SENSEM}
N 140 -230 140 -200 {lab=SENSEP}
N 140 -230 160 -230 {lab=SENSEP}
N 140 -270 160 -270 {lab=SENSEM}
N 190 -250 300 -250 {lab=GND}
N 120 -250 190 -250 {lab=GND}
N 420 -320 420 -270 {lab=#net1}
N 400 -320 420 -320 {lab=#net1}
N 420 -230 420 -180 {lab=#net2}
N 400 -180 420 -180 {lab=#net2}
N 420 -320 460 -320 {lab=#net1}
N 420 -230 460 -230 {lab=#net2}
N 760 -290 840 -290 {lab=#net3}
N 760 -320 760 -290 {lab=#net3}
N 760 -250 840 -250 {lab=#net4}
N 760 -250 760 -230 {lab=#net4}
N 1060 -270 1140 -270 {lab=OUT}
N 760 -230 760 -160 {lab=#net4}
N 760 -390 760 -320 {lab=#net3}
N 960 -270 1060 -270 {lab=OUT}
N 280 -230 360 -230 {lab=#net5}
N 280 -270 360 -270 {lab=#net6}
N 760 -410 760 -400 {lab=#net3}
N 1060 -400 1060 -270 {lab=OUT}
N 760 -150 760 -140 {lab=#net4}
N 1060 -150 1140 -150 {lab=GNDREF}
N 760 -400 760 -390 {lab=#net3}
N 1060 -410 1060 -400 {lab=OUT}
N 760 -160 760 -150 {lab=#net4}
N 1060 -150 1060 -140 {lab=GNDREF}
C {opamp_3zki_ina_first.sym} 340 -320 0 0 {name=x1}
C {opamp_3zki_ina_first.sym} 340 -180 2 1 {name=x2}
C {devices/lab_pin.sym} 280 -140 0 0 {name=p2 sig_type=std_logic lab=VB}
C {devices/ipin.sym} 120 -340 0 0 {name=p3 lab=INM}
C {devices/ipin.sym} 120 -160 0 0 {name=p4 lab=INP}
C {devices/lab_pin.sym} 340 -140 3 0 {name=p5 sig_type=std_logic lab=VDD}
C {devices/ipin.sym} 120 -300 0 0 {name=p8 lab=SENSEM}
C {devices/ipin.sym} 120 -200 0 0 {name=p9 lab=SENSEP}
C {IP62LIB/RS.sym} 220 -270 1 0 {name=R1
w=4e-6
R=2138
l=85e-6
model=F_RS
spiceprefix=X
tc1=0
tc2=0
m=1}
C {IP62LIB/RS.sym} 520 -320 1 0 {name=R3
w=4e-6
R=2020
l=80e-6
model=F_RS
spiceprefix=X
tc1=0
tc2=0
m=1}
C {IP62LIB/RS.sym} 520 -230 1 0 {name=R4
w=4e-6
R=2020
l=80e-6
model=F_RS
spiceprefix=X
tc1=0
tc2=0
m=1}
C {IP62LIB/RS.sym} 580 -230 1 0 {name=R5
w=4e-6
R=2020
l=80e-6
model=F_RS
spiceprefix=X
tc1=0
tc2=0
m=1}
C {IP62LIB/RS.sym} 640 -230 1 0 {name=R6
w=4e-6
R=2020
l=80e-6
model=F_RS
spiceprefix=X
tc1=0
tc2=0
m=1}
C {IP62LIB/RS.sym} 700 -230 1 0 {name=R7
w=4e-6
R=2020
l=80e-6
model=F_RS
spiceprefix=X
tc1=0
tc2=0
m=1}
C {IP62LIB/RS.sym} 760 -230 1 0 {name=R8
w=4e-6
R=2020
l=80e-6
model=F_RS
spiceprefix=X
tc1=0
tc2=0
m=1}
C {IP62LIB/RS.sym} 580 -320 1 0 {name=R9
w=4e-6
R=2020
l=80e-6
model=F_RS
spiceprefix=X
tc1=0
tc2=0
m=1}
C {IP62LIB/RS.sym} 640 -320 1 0 {name=R10
w=4e-6
R=2020
l=80e-6
model=F_RS
spiceprefix=X
tc1=0
tc2=0
m=1}
C {IP62LIB/RS.sym} 700 -320 1 0 {name=R11
w=4e-6
R=2020
l=80e-6
model=F_RS
spiceprefix=X
tc1=0
tc2=0
m=1}
C {IP62LIB/RS.sym} 760 -320 1 0 {name=R12
w=4e-6
R=2020
l=80e-6
model=F_RS
spiceprefix=X
tc1=0
tc2=0
m=1}
C {opamp_3zki_ina_out.sym} 900 -270 2 1 {name=x3}
C {devices/lab_pin.sym} 840 -230 2 1 {name=p10 sig_type=std_logic lab=VB}
C {devices/lab_pin.sym} 900 -230 3 0 {name=p11 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 900 -310 3 1 {name=p12 sig_type=std_logic lab=GND}
C {devices/opin.sym} 1140 -270 0 0 {name=p13 lab=OUT}
C {IP62LIB/RS.sym} 280 -270 1 0 {name=R2
w=4e-6
R=2138
l=85e-6
model=F_RS
spiceprefix=X
tc1=0
tc2=0
m=1}
C {IP62LIB/RS.sym} 420 -270 1 0 {name=R23
w=4e-6
R=2138
l=85e-6
model=F_RS
spiceprefix=X
tc1=0
tc2=0
m=1}
C {IP62LIB/RS.sym} 220 -230 1 0 {name=R24
w=4e-6
R=2138
l=85e-6
model=F_RS
spiceprefix=X
tc1=0
tc2=0
m=1}
C {IP62LIB/RS.sym} 280 -230 1 0 {name=R25
w=4e-6
R=2138
l=85e-6
model=F_RS
spiceprefix=X
tc1=0
tc2=0
m=1}
C {IP62LIB/RS.sym} 420 -230 1 0 {name=R26
w=4e-6
R=2138
l=85e-6
model=F_RS
spiceprefix=X
tc1=0
tc2=0
m=1}
C {devices/ipin.sym} 1140 -150 2 0 {name=p16 lab=GNDREF}
C {devices/ipin.sym} 280 -360 0 0 {name=p1 lab=VB}
C {devices/iopin.sym} 340 -360 3 0 {name=p7 lab=VDD}
C {devices/iopin.sym} 120 -250 2 0 {name=p6 lab=GND}
C {IP62LIB/RS.sym} 820 -410 1 0 {name=R67
w=4e-6
R=2020
l=80e-6
model=F_RS
spiceprefix=X
tc1=0
tc2=0
m=1}
C {IP62LIB/RS.sym} 880 -410 1 0 {name=R68
w=4e-6
R=2020
l=80e-6
model=F_RS
spiceprefix=X
tc1=0
tc2=0
m=1}
C {IP62LIB/RS.sym} 940 -410 1 0 {name=R69
w=4e-6
R=2020
l=80e-6
model=F_RS
spiceprefix=X
tc1=0
tc2=0
m=1}
C {IP62LIB/RS.sym} 1000 -410 1 0 {name=R70
w=4e-6
R=2020
l=80e-6
model=F_RS
spiceprefix=X
tc1=0
tc2=0
m=1}
C {IP62LIB/RS.sym} 1060 -410 1 0 {name=R71
w=4e-6
R=2020
l=80e-6
model=F_RS
spiceprefix=X
tc1=0
tc2=0
m=1}
C {IP62LIB/RS.sym} 820 -140 1 1 {name=R112
w=4e-6
R=2020
l=80e-6
model=F_RS
spiceprefix=X
tc1=0
tc2=0
m=1}
C {IP62LIB/RS.sym} 880 -140 1 1 {name=R113
w=4e-6
R=2020
l=80e-6
model=F_RS
spiceprefix=X
tc1=0
tc2=0
m=1}
C {IP62LIB/RS.sym} 940 -140 1 1 {name=R114
w=4e-6
R=2020
l=80e-6
model=F_RS
spiceprefix=X
tc1=0
tc2=0
m=1}
C {IP62LIB/RS.sym} 1000 -140 1 1 {name=R115
w=4e-6
R=2020
l=80e-6
model=F_RS
spiceprefix=X
tc1=0
tc2=0
m=1}
C {IP62LIB/RS.sym} 1060 -140 1 1 {name=R116
w=4e-6
R=2020
l=80e-6
model=F_RS
spiceprefix=X
tc1=0
tc2=0
m=1}
