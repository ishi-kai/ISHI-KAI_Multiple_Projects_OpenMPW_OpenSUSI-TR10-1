v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {TR-1um_frame/OSS_FRAME.sym} 70 20 0 0 {name=x1}
