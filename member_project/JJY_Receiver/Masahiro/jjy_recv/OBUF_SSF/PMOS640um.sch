v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 260 -450 260 -310 {lab=#net1}
N 260 -280 290 -280 {lab=#net1}
N 290 -450 290 -280 {lab=#net1}
N 210 -330 320 -330 {lab=#net2}
N 320 -330 320 -280 {lab=#net2}
N 320 -330 420 -330 {lab=#net2}
N 420 -330 420 -280 {lab=#net2}
N 360 -450 360 -310 {lab=#net1}
N 460 -450 460 -310 {lab=#net1}
N 260 -450 290 -450 {lab=#net1}
N 290 -450 360 -450 {lab=#net1}
N 360 -450 460 -450 {lab=#net1}
N 360 -250 360 -210 {lab=#net3}
N 260 -210 360 -210 {lab=#net3}
N 360 -210 460 -210 {lab=#net3}
N 460 -250 460 -210 {lab=#net3}
N 360 -280 390 -280 {lab=#net1}
N 390 -450 390 -280 {lab=#net1}
N 460 -280 490 -280 {lab=#net1}
N 490 -450 490 -280 {lab=#net1}
N 460 -450 490 -450 {lab=#net1}
N 420 -330 520 -330 {lab=#net2}
N 520 -330 520 -280 {lab=#net2}
N 560 -250 560 -210 {lab=#net3}
N 460 -210 560 -210 {lab=#net3}
N 560 -450 560 -310 {lab=#net1}
N 490 -450 560 -450 {lab=#net1}
N 560 -280 590 -280 {lab=#net1}
N 590 -450 590 -280 {lab=#net1}
N 560 -450 590 -450 {lab=#net1}
N 190 -450 260 -450 {lab=#net1}
N 260 -250 260 -210 {lab=#net3}
N 260 -210 260 -130 {lab=#net3}
N 300 -510 330 -510 {lab=#net1}
N 330 -540 330 -510 {lab=#net1}
N 300 -540 330 -540 {lab=#net1}
N 260 -540 260 -510 {lab=#net1}
N 300 -480 330 -480 {lab=#net1}
N 330 -510 330 -480 {lab=#net1}
N 260 -540 300 -540 {lab=#net1}
N 370 -510 400 -510 {lab=#net1}
N 400 -540 400 -510 {lab=#net1}
N 370 -540 400 -540 {lab=#net1}
N 330 -540 330 -510 {lab=#net1}
N 370 -480 400 -480 {lab=#net1}
N 400 -510 400 -480 {lab=#net1}
N 330 -540 370 -540 {lab=#net1}
N 440 -510 470 -510 {lab=#net1}
N 470 -540 470 -510 {lab=#net1}
N 440 -540 470 -540 {lab=#net1}
N 400 -540 400 -510 {lab=#net1}
N 440 -480 470 -480 {lab=#net1}
N 470 -510 470 -480 {lab=#net1}
N 400 -540 440 -540 {lab=#net1}
N 510 -510 540 -510 {lab=#net1}
N 540 -540 540 -510 {lab=#net1}
N 510 -540 540 -540 {lab=#net1}
N 470 -540 470 -510 {lab=#net1}
N 510 -480 540 -480 {lab=#net1}
N 540 -510 540 -480 {lab=#net1}
N 470 -540 510 -540 {lab=#net1}
N 300 -480 300 -450 {lab=#net1}
N 580 -510 610 -510 {lab=#net1}
N 610 -540 610 -510 {lab=#net1}
N 580 -540 610 -540 {lab=#net1}
N 580 -480 610 -480 {lab=#net1}
N 610 -510 610 -480 {lab=#net1}
N 540 -540 580 -540 {lab=#net1}
N 650 -510 680 -510 {lab=#net1}
N 680 -540 680 -510 {lab=#net1}
N 650 -540 680 -540 {lab=#net1}
N 650 -480 680 -480 {lab=#net1}
N 680 -510 680 -480 {lab=#net1}
N 610 -540 650 -540 {lab=#net1}
N 720 -510 750 -510 {lab=#net1}
N 750 -540 750 -510 {lab=#net1}
N 720 -540 750 -540 {lab=#net1}
N 720 -480 750 -480 {lab=#net1}
N 750 -510 750 -480 {lab=#net1}
N 680 -540 720 -540 {lab=#net1}
N 790 -510 820 -510 {lab=#net1}
N 820 -540 820 -510 {lab=#net1}
N 790 -540 820 -540 {lab=#net1}
N 790 -480 820 -480 {lab=#net1}
N 820 -510 820 -480 {lab=#net1}
N 750 -540 790 -540 {lab=#net1}
N 220 -330 220 -280 {lab=#net2}
C {MP.sym} 220 -280 0 0 {name=M5 model=PMOS w=10u l=2u nrd=0 nrs=0 m=16 spiceprefix=X}
C {MP.sym} 320 -280 0 0 {name=M2 model=PMOS w=10u l=2u nrd=0 nrs=0 m=16 spiceprefix=X}
C {MP.sym} 420 -280 0 0 {name=M7 model=PMOS w=10u l=2u nrd=0 nrs=0 m=16 spiceprefix=X}
C {MP.sym} 520 -280 0 0 {name=M12 model=PMOS w=10u l=2u nrd=0 nrs=0 m=16 spiceprefix=X}
C {MP.sym} 260 -510 0 0 {name=M16 model=PMOS w=10u l=2u nrd=0 nrs=0 m=1 spiceprefix=X}
C {MP.sym} 330 -510 0 0 {name=M17 model=PMOS w=10u l=2u nrd=0 nrs=0 m=1 spiceprefix=X}
C {MP.sym} 400 -510 0 0 {name=M18 model=PMOS w=10u l=2u nrd=0 nrs=0 m=1 spiceprefix=X}
C {MP.sym} 470 -510 0 0 {name=M19 model=PMOS w=10u l=2u nrd=0 nrs=0 m=1 spiceprefix=X}
C {MP.sym} 540 -510 0 0 {name=M27 model=PMOS w=10u l=2u nrd=0 nrs=0 m=1 spiceprefix=X}
C {MP.sym} 610 -510 0 0 {name=M28 model=PMOS w=10u l=2u nrd=0 nrs=0 m=1 spiceprefix=X}
C {MP.sym} 680 -510 0 0 {name=M29 model=PMOS w=10u l=2u nrd=0 nrs=0 m=1 spiceprefix=X}
C {MP.sym} 750 -510 0 0 {name=M30 model=PMOS w=10u l=2u nrd=0 nrs=0 m=1 spiceprefix=X}
